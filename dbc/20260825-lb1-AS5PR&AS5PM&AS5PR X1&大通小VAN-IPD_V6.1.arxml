                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_CHCANFD/IPD_NM_BSMtoRMS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_BSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_PTCANFD/IPD_NM_BSMtoRMS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_BSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_SFCANFD/IPD_NM_BSMtoRMS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_BSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_BKPCANFD/IPD_NM_NOSSta_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_CHCANFD/IPD_NM_NOSSta_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOSSta_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_PTCANFD/IPD_NM_NOSSta_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOSSta_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOSSta_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_SFCANFD/IPD_NM_NOSSta_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOSSta_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_BKPCANFD/IPD_NM_NOStoRMS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_CHCANFD/IPD_NM_NOStoRMS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_PTCANFD/IPD_NM_NOStoRMS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_NOStoRMS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_SFCANFD/IPD_NM_NOStoRMS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_NOStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_BKPCANFD/IPD_NM_PBSMtoRMS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_PBSMtoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_CHCANFD/IPD_NM_PBSMtoRMS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_PBSMtoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_PTCANFD/IPD_NM_PBSMtoRMS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_PBSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_PBSMtoRMS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_SFCANFD/IPD_NM_PBSMtoRMS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_PBSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_BKPCANFD/IPD_NM_RMSSta_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMSSta_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_CHCANFD/IPD_NM_RMSSta_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMSSta_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_PTCANFD/IPD_NM_RMSSta_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMSSta_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_SFCANFD/IPD_NM_RMSSta_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMSSta_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_BKPCANFD/IPD_NM_RMStoNOS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_CHCANFD/IPD_NM_RMStoNOS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_PTCANFD/IPD_NM_RMStoNOS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_SFCANFD/IPD_NM_RMStoNOS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RMStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_BKPCANFD/IPD_NM_RSStoNOS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoNOS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_CHCANFD/IPD_NM_RSStoNOS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoNOS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_PTCANFD/IPD_NM_RSStoNOS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_SFCANFD/IPD_NM_RSStoNOS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_BKPCANFD/IPD_NM_RSStoRMS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_CHCANFD/IPD_NM_RSStoRMS_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoRMS_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_PTCANFD/IPD_NM_RSStoRMS_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_SFCANFD/IPD_NM_RSStoRMS_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_RSStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_BKPCANFD/IPD_NOI_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NOI_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_CHCANFD/IPD_NOI_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NOI_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_PTCANFD/IPD_NOI_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NOI_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NOI_SFCANFD/IPD_NOI_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NOI_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_BKPCANFD/IPD_NWI_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NWI_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_CHCANFD/IPD_NWI_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NWI_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_PTCANFD/IPD_NWI_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NWI_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NWI_SFCANFD/IPD_NWI_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NWI_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_VehLckCtrlReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_VehLckCtrlReq/IPD_VehLckCtrlReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_VehLckCtrlReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGMaxTqLmt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGMaxTqLmt_Nm/ISGMaxTqLmt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ISGMaxTqLmt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGMinTqLmt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGMinTqLmt_Nm/ISGMinTqLmt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ISGMinTqLmt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGTqTgt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ISGTqTgt_Nm/ISGTqTgt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ISGTqTgt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IdentityChlg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IdentityChlg/IdentityChlg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IdentityChlg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IgnOffTime</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IgnOffTime/IgnOffTime</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IgnOffTime</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IgnOffTimeV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IgnOffTimeV/IgnOffTimeV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IgnOffTimeV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/JAMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/JAMsgReq/JAMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/JAMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LADSCurToEndPntDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LADSCurToEndPntDist/LADSCurToEndPntDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSCurToEndPntDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LADSInfoDispReqToICM_HPP</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LADSInfoDispReqToICM_HPP/LADSInfoDispReqToICM_HPP</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LADSInfoDispReqToICM_HPP</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCASelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCASelReq/LCASelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LCASelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRInHMI</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRInHMI/LCRInHMI</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LCRInHMI</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRSwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRSwDspCmd/LCRSwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LCRSwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LCRSwReq/LCRSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LCRSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWAdoWrnngReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWAdoWrnngReq/LDWAdoWrnngReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWAdoWrnngReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWLKAHptWrnngReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWLKAHptWrnngReq/LDWLKAHptWrnngReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKAHptWrnngReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWLKASwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWLKASwReq/LDWLKASwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWLKASwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWSnstvtLvlReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWSnstvtLvlReq/LDWSnstvtLvlReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWSnstvtLvlReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LDWStsForEdr/LDWStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDWStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LFCTWrnng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LFCTWrnng/LFCTWrnng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LFCTWrnng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LFCTWrnng_ADAS</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LFCTWrnng_ADAS/LFCTWrnng_ADAS</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LFCTWrnng_ADAS</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHSWPwrSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHSWPwrSts/LHSWPwrSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHSWPwrSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCUAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/LHZCUAvlbly/LHZCUAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LHZCUAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C0</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C0/Lane0_C0</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_C0</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C1/Lane0_C1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_C1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C2/Lane0_C2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_C2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_C3/Lane0_C3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_C3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ExistPrblty/Lane0_ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ID/Lane0_ID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_ID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_MarkerColor</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_MarkerColor/Lane0_MarkerColor</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_MarkerColor</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_MarkerType</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_MarkerType/Lane0_MarkerType</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_MarkerType</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_Part0_SyncFrameIndex</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_Part0_SyncFrameIndex/Lane0_Part0_SyncFrameIndex</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_Part0_SyncFrameIndex</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ViewRangeEnd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ViewRangeEnd/Lane0_ViewRangeEnd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_ViewRangeEnd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ViewRangeStart</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_ViewRangeStart/Lane0_ViewRangeStart</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_ViewRangeStart</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_location</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane0_location/Lane0_location</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane0_location</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C0</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C0/Lane1_C0</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_C0</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C1/Lane1_C1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_C1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C2/Lane1_C2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_C2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_C3/Lane1_C3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_C3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ExistPrblty/Lane1_ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ID/Lane1_ID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_ID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_MarkerColor</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_MarkerColor/Lane1_MarkerColor</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_MarkerColor</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_MarkerType</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_MarkerType/Lane1_MarkerType</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_MarkerType</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_Part0_SyncFrameIndex</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_Part0_SyncFrameIndex/Lane1_Part0_SyncFrameIndex</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_Part0_SyncFrameIndex</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ViewRangeEnd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ViewRangeEnd/Lane1_ViewRangeEnd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_ViewRangeEnd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ViewRangeStart</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_ViewRangeStart/Lane1_ViewRangeStart</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_ViewRangeStart</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_location</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane1_location/Lane1_location</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane1_location</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C0</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C0/Lane2_C0</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_C0</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C1/Lane2_C1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_C1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C2/Lane2_C2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_C2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_C3/Lane2_C3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_C3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ExistPrblty/Lane2_ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ID/Lane2_ID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_ID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_MarkerColor</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_MarkerColor/Lane2_MarkerColor</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_MarkerColor</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_MarkerType</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_MarkerType/Lane2_MarkerType</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_MarkerType</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_Part0_SyncFrameIndex</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_Part0_SyncFrameIndex/Lane2_Part0_SyncFrameIndex</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_Part0_SyncFrameIndex</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ViewRangeEnd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ViewRangeEnd/Lane2_ViewRangeEnd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_ViewRangeEnd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ViewRangeStart</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_ViewRangeStart/Lane2_ViewRangeStart</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_ViewRangeStart</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_location</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane2_location/Lane2_location</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane2_location</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C0</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C0/Lane3_C0</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_C0</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C1/Lane3_C1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_C1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C2/Lane3_C2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_C2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_C3/Lane3_C3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_C3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ExistPrblty/Lane3_ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ID/Lane3_ID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_ID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_MarkerColor</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_MarkerColor/Lane3_MarkerColor</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_MarkerColor</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_MarkerType</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_MarkerType/Lane3_MarkerType</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_MarkerType</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_Part0_SyncFrameIndex</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_Part0_SyncFrameIndex/Lane3_Part0_SyncFrameIndex</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_Part0_SyncFrameIndex</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ViewRangeEnd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ViewRangeEnd/Lane3_ViewRangeEnd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_ViewRangeEnd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ViewRangeStart</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_ViewRangeStart/Lane3_ViewRangeStart</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_ViewRangeStart</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_location</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Lane3_location/Lane3_location</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Lane3_location</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MONSAMTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MONSAMTqReq_Nm/MONSAMTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MONSAMTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MONTMTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MONTMTqReq_Nm/MONTMTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MONTMTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MainBeamLghtOn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MainBeamLghtOn/MainBeamLghtOn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MainBeamLghtOn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemParkngBtnRcnm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemParkngBtnRcnm/MemParkngBtnRcnm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemParkngBtnRcnm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemPkngSlntPtrlEnbSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemPkngSlntPtrlEnbSwReq/MemPkngSlntPtrlEnbSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSlntPtrlEnbSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemPkngSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MemPkngSwReq/MemPkngSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MemPkngSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MnvrngPntDistNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MnvrngPntDistNav/MnvrngPntDistNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MnvrngPntDistNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MnvrngPntTypNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/MnvrngPntTypNav/MnvrngPntTypNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/MnvrngPntTypNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOACitySysMsg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOACitySysMsg/NOACitySysMsg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOACitySysMsg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOADistDecMsg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOADistDecMsg/NOADistDecMsg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOADistDecMsg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAETCSetDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAETCSetDspCmd/NOAETCSetDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAETCSetDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAETCSetSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAETCSetSwReq/NOAETCSetSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAETCSetSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOALaneSetDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOALaneSetDspCmd/NOALaneSetDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOALaneSetDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOALaneSetSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOALaneSetSwReq/NOALaneSetSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOALaneSetSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAQukChgSwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAQukChgSwDspCmd/NOAQukChgSwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAQukChgSwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAQukChgSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAQukChgSwReq/NOAQukChgSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAQukChgSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAReportSetDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAReportSetDspCmd/NOAReportSetDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAReportSetDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAReportSetSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOAReportSetSwReq/NOAReportSetSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOAReportSetSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPCitySwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPCitySwDspCmd/NOPCitySwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPCitySwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPCitySwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPCitySwReq/NOPCitySwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPCitySwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSwDspCmd/NOPSwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSwReq/NOPSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSysMsg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NOPSysMsg/NOPSysMsg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NOPSysMsg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssQuit</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssQuit/NarRoVslAssQuit</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarRoVslAssQuit</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssSwReq/NarRoVslAssSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarRoVslAssSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssSwResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarRoVslAssSwResp/NarRoVslAssSwResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarRoVslAssSwResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarrowRoadBackwardSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarrowRoadBackwardSts/NarrowRoadBackwardSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarrowRoadBackwardSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarrowRoadForwardSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarrowRoadForwardSts/NarrowRoadForwardSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarrowRoadForwardSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstBtnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstBtnSts/NarwSpcAstBtnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarwSpcAstBtnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstSwReq/NarwSpcAstSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarwSpcAstSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NarwSpcAstSwSts/NarwSpcAstSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NarwSpcAstSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCndSpdLmtVal</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCndSpdLmtVal/NavCndSpdLmtVal</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavCndSpdLmtVal</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCrntRoadTyp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCrntRoadTyp/NavCrntRoadTyp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavCrntRoadTyp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCtryCode_ISO</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavCtryCode_ISO/NavCtryCode_ISO</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavCtryCode_ISO</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavDistFromFrtEleccEye</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavDistFromFrtEleccEye/NavDistFromFrtEleccEye</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavDistFromFrtEleccEye</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavItvalSpdDetnDistRetDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavItvalSpdDetnDistRetDist/NavItvalSpdDetnDistRetDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavItvalSpdDetnDistRetDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavNewIconDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavNewIconDist/NavNewIconDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavNewIconDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavNextRampOffset</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavNextRampOffset/NavNextRampOffset</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavNextRampOffset</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtTyp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtTyp/NavSpdLmtTyp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavSpdLmtTyp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtVal</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtVal/NavSpdLmtVal</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavSpdLmtVal</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtValSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtValSts/NavSpdLmtValSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavSpdLmtValSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtValUnit</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSpdLmtValUnit/NavSpdLmtValUnit</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavSpdLmtValUnit</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NavSts/NavSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NavSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSwDspCmd/NonDirectDMSSwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NonDirectDMSSwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSwReq/NonDirectDMSSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NonDirectDMSSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NonDirectDMSSysSts/NonDirectDMSSysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NonDirectDMSSysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NorthVelocityRTK</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NorthVelocityRTK/NorthVelocityRTK</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NorthVelocityRTK</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssConfrmSwDscmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwDscmd/NrwroadBwdAssConfrmSwDscmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadBwdAssConfrmSwDscmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssConfrmSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwReq/NrwroadBwdAssConfrmSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadBwdAssConfrmSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssMesg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssMesg/NrwroadBwdAssMesg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadBwdAssMesg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwReq/NrwroadBwdAssSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadBwdAssSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwSts/NrwroadBwdAssSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadBwdAssSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdBtnDsp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdBtnDsp/NrwroadFwdBtnDsp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdBtnDsp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdCndNotSt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdCndNotSt/NrwroadFwdCndNotSt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdCndNotSt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdCtlReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdCtlReq/NrwroadFwdCtlReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdCtlReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDsp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDsp/NrwroadFwdDsp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDsp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDst360Req</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDst360Req/NrwroadFwdDst360Req</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDst360Req</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstBtnDsp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstBtnDsp/NrwroadFwdDstBtnDsp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDstBtnDsp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstL/NrwroadFwdDstL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDstL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstR/NrwroadFwdDstR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDstR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstTostDsp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdDstTostDsp/NrwroadFwdDstTostDsp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdDstTostDsp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdReDst</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdReDst/NrwroadFwdReDst</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdReDst</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdReq/NrwroadFwdReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdSta</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdSta/NrwroadFwdSta</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdSta</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadFwdSwSts/NrwroadFwdSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadFwdSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadsltReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadsltReq/NrwroadsltReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadsltReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadsltSta</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/NrwroadsltSta/NrwroadsltSta</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/NrwroadsltSta</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OnBdChrgrOptAltPwr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OnBdChrgrOptAltPwr/OnBdChrgrOptAltPwr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrOptAltPwr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrVal</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrVal/OtsdAirTemCrVal</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemCrVal</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrValMsk</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrValMsk/OtsdAirTemCrValMsk</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemCrValMsk</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrValV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/OtsdAirTemCrValV/OtsdAirTemCrValV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OtsdAirTemCrValV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PDCSysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PDCSysSts/PDCSysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDCSysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PDSysKeyPsAvlbl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PDSysKeyPsAvlbl/PDSysKeyPsAvlbl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PDSysKeyPsAvlbl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSts/PEBSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSwReq/PEBSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSwResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBSwResp/PEBSwResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBSwResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBWarngReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PEBWarngReq/PEBWarngReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PEBWarngReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_PTAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PICU_PTAvlbly/PICU_PTAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PICU_PTAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirAvlSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirAvlSts/ParkngDirAvlSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngDirAvlSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirSw/ParkngDirSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngDirSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirSwResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngDirSwResp/ParkngDirSwResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngDirSwResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngEndDis</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngEndDis/ParkngEndDis</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngEndDis</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngInPrgs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngInPrgs/ParkngInPrgs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngInPrgs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngNCPAvlSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngNCPAvlSts/ParkngNCPAvlSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngNCPAvlSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkCrsSts/ParkngOutBkCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutBkCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkLCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkLCrsSts/ParkngOutBkLCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutBkLCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkRCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutBkRCrsSts/ParkngOutBkRCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutBkRCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutDircnSelResult</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutDircnSelResult/ParkngOutDircnSelResult</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutDircnSelResult</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFLCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFLCrsSts/ParkngOutFLCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutFLCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFLParllSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFLParllSts/ParkngOutFLParllSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutFLParllSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFRCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFRCrsSts/ParkngOutFRCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutFRCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFRParllSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFRParllSts/ParkngOutFRParllSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutFRParllSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFrtCrsSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngOutFrtCrsSts/ParkngOutFrtCrsSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngOutFrtCrsSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngSlotFindSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngSlotFindSts/ParkngSlotFindSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngSlotFindSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngSpdSwResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ParkngSpdSwResp/ParkngSpdSwResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ParkngSpdSwResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysADASFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysADASFltSts/PilotSysADASFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysADASFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrF1FltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrF1FltSts/PilotSysAVCamrF1FltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrF1FltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrF3FltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrF3FltSts/PilotSysAVCamrF3FltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrF3FltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrFLSFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrFLSFltSts/PilotSysAVCamrFLSFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrFLSFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrFRSFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrFRSFltSts/PilotSysAVCamrFRSFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrFRSFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRFltSts/PilotSysAVCamrRFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrRFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRLSFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRLSFltSts/PilotSysAVCamrRLSFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrRLSFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRRSFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysAVCamrRRSFltSts/PilotSysAVCamrRRSFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysAVCamrRRSFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysFDRFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysFDRFltSts/PilotSysFDRFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysFDRFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysFLIDARFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysFLIDARFltSts/PilotSysFLIDARFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysFLIDARFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrFFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrFFltSts/PilotSysHDAVMCamrFFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysHDAVMCamrFFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrLHFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrLHFltSts/PilotSysHDAVMCamrLHFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysHDAVMCamrLHFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrRFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRFltSts/PilotSysHDAVMCamrRFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysHDAVMCamrRFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrRHFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRHFltSts/PilotSysHDAVMCamrRHFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysHDAVMCamrRHFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysLFSDAFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysLFSDAFltSts/PilotSysLFSDAFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysLFSDAFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysLHRDAFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysLHRDAFltSts/PilotSysLHRDAFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysLHRDAFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysMsg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysMsg/PilotSysMsg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysMsg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysRFSDAFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysRFSDAFltSts/PilotSysRFSDAFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysRFSDAFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysRHRDAFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysRHRDAFltSts/PilotSysRHRDAFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysRHRDAFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysUSSFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PilotSysUSSFltSts/PilotSysUSSFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PilotSysUSSFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PosALCFailed</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PosALCFailed/PosALCFailed</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PosALCFailed</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PositionAttitudeStatus</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PositionAttitudeStatus/PositionAttitudeStatus</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PositionAttitudeStatus</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PrvOutSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PrvOutSts/PrvOutSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PrvOutSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PwrDMd_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PwrDMd_enum/PwrDMd_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrDMd_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PwrReq_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/PwrReq_flg/PwrReq_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrReq_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RAAlrWorDis</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RAAlrWorDis/RAAlrWorDis</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RAAlrWorDis</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RACtlReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RACtlReq/RACtlReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RACtlReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RADSSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RADSSwSts/RADSSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RADSSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RASysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RASysSts/RASysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RASysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RCTSysSelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RCTSysSelReq/RCTSysSelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RCTSysSelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RCWSelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RCWSelReq/RCWSelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RCWSelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RDASwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RDASwReq/RDASwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDASwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFCTWrnng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFCTWrnng/RFCTWrnng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFCTWrnng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFCTWrnng_ADAS</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RFCTWrnng_ADAS/RFCTWrnng_ADAS</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RFCTWrnng_ADAS</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCUAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCUAvlbly/RHZCUAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCUeFs1Sts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RHZCUeFs1Sts/RHZCUeFs1Sts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RHZCUeFs1Sts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLObsRng/RLObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSObsRng/RLSObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSUSSSts/RLSUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSideObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLSideObsRng/RLSideObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLSideObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTirePrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTirePrs/RLTirePrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTirePrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTirePrsV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTirePrsV/RLTirePrsV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTirePrsV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireSts/RLTireSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireTem/RLTireTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLTireTemV/RLTireTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLTireTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RLUSSSts/RLUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RMLUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RMLUSSSts/RMLUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMLUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RMRUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RMRUSSSts/RMRUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RMRUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RPShockDistL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RPShockDistL/RPShockDistL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RPShockDistL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RPShockDistR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RPShockDistR/RPShockDistR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RPShockDistR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRObsRng/RRObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSObsRng/RRSObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSUSSSts/RRSUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSideObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRSideObsRng/RRSideObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRSideObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTirePrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTirePrs/RRTirePrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTirePrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTirePrsV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTirePrsV/RRTirePrsV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTirePrsV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireSts/RRTireSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireTem/RRTireTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRTireTemV/RRTireTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRTireTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RRUSSSts/RRUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCUIgnDiagSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCUIgnDiagSts/RZCUIgnDiagSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUIgnDiagSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCUIgnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCUIgnSts/RZCUIgnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUIgnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_BKBCANFDAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_BKBCANFDAvlbly/RZCU_BKBCANFDAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_BKBCANFDAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ResetCnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ResetCnt/ResetCnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ResetCnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadHeightL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadHeightL/RoadHeightL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadHeightL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadHeightR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadHeightR/RoadHeightR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadHeightR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL/RoadProfileShockConfidenceL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL1/RoadProfileShockConfidenceL1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL2/RoadProfileShockConfidenceL2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL3/RoadProfileShockConfidenceL3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR/RoadProfileShockConfidenceR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR1/RoadProfileShockConfidenceR1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR2/RoadProfileShockConfidenceR2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR3/RoadProfileShockConfidenceR3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL/RoadProfileShockDetectedL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL1/RoadProfileShockDetectedL1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL2/RoadProfileShockDetectedL2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL3/RoadProfileShockDetectedL3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR/RoadProfileShockDetectedR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR1/RoadProfileShockDetectedR1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR2/RoadProfileShockDetectedR2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR3/RoadProfileShockDetectedR3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL1/RoadProfileShockDistL1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL2/RoadProfileShockDistL2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistL3/RoadProfileShockDistL3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR1/RoadProfileShockDistR1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR2/RoadProfileShockDistR2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockDistR3/RoadProfileShockDistR3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL/RoadProfileShockHeightL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL1/RoadProfileShockHeightL1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL2/RoadProfileShockHeightL2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL3/RoadProfileShockHeightL3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR/RoadProfileShockHeightR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR1/RoadProfileShockHeightR1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR2/RoadProfileShockHeightR2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR3/RoadProfileShockHeightR3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockLevelL</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockLevelL/RoadProfileShockLevelL</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockLevelL</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockLevelR</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RoadProfileShockLevelR/RoadProfileShockLevelR</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockLevelR</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Rolloff2Min_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Rolloff2Min_flg/Rolloff2Min_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Rolloff2Min_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RolloffHld_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RolloffHld_flg/RolloffHld_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RolloffHld_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrMidLObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrMidLObsRng/RrMidLObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrMidLObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrMidRObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrMidRObsRng/RrMidRObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrMidRObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrObsDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrObsDist/RrObsDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrObsDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrPDCAudWrnng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrPDCAudWrnng/RrPDCAudWrnng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrPDCAudWrnng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrTireStdPrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RrTireStdPrs/RrTireStdPrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrTireStdPrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RstrFctryDeftsReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RstrFctryDeftsReq/RstrFctryDeftsReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RstrFctryDeftsReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDMAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDMAvlbly/SDMAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDMAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFAudWrnng_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFAudWrnng_IPD/SLIFAudWrnng_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFAudWrnng_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFSts_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFSts_IPD/SLIFSts_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFSts_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFSysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFSysFltSts/SLIFSysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFSysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtIndReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtIndReq/SLIFUpdtIndReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtIndReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtIndResp_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtIndResp_IPD/SLIFUpdtIndResp_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtIndResp_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtInd_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtInd_IPD/SLIFUpdtInd_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtInd_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFWrnngMdReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFWrnngMdReq/SLIFWrnngMdReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFWrnngMdReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFWrnngMdResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFWrnngMdResp/SLIFWrnngMdResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFWrnngMdResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCLowPwrDwn_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCLowPwrDwn_flg/SOCLowPwrDwn_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCLowPwrDwn_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCLvl_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCLvl_enum/SOCLvl_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCLvl_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCMd_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCMd_enum/SOCMd_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCMd_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz1/SatAz1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz10/SatAz10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz10</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz11/SatAz11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz11</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz12/SatAz12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz12</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz13/SatAz13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz13</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz14</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz14/SatAz14</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz14</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz15/SatAz15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz15</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz16</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz16/SatAz16</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz16</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz17</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz17/SatAz17</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz17</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz18/SatAz18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz18</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz19</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz19/SatAz19</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz19</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz2/SatAz2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz20/SatAz20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz20</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz3/SatAz3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz4</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz4/SatAz4</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz4</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz5</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz5/SatAz5</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz5</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz6</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz6/SatAz6</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz6</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz7</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz7/SatAz7</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz7</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz8</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz8/SatAz8</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz8</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz9</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz9/SatAz9</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz9</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO1/SatCNO1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO10/SatCNO10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO10</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO11/SatCNO11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO11</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO12/SatCNO12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO12</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO13/SatCNO13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO13</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO14</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO14/SatCNO14</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO14</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO15/SatCNO15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO15</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO16</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO16/SatCNO16</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO16</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO17</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO17/SatCNO17</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO17</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO18/SatCNO18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO18</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO19</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO19/SatCNO19</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO19</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO2/SatCNO2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO20/SatCNO20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO20</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO3/SatCNO3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO4</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO4/SatCNO4</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO4</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO5</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO5/SatCNO5</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO5</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO6</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO6/SatCNO6</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO6</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO7</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO7/SatCNO7</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO7</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO8</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO8/SatCNO8</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO8</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO9</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO9/SatCNO9</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO9</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv1/SatElv1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv10/SatElv10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv10</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv11/SatElv11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv11</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv12/SatElv12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv12</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv13/SatElv13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv13</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv14</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv14/SatElv14</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv14</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv15/SatElv15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv15</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv16</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv16/SatElv16</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv16</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv17</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv17/SatElv17</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv17</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv18/SatElv18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv18</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv19</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv19/SatElv19</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv19</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv2/SatElv2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv20/SatElv20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv20</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv3/SatElv3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv4</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv4/SatElv4</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv4</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv5</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv5/SatElv5</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv5</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv6</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv6/SatElv6</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv6</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv7</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv7/SatElv7</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv7</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv8</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv8/SatElv8</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv8</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv9</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv9/SatElv9</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv9</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID1/SatID1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID10</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID10/SatID10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID10</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID11</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID11/SatID11</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID11</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID12</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID12/SatID12</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID12</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID13</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID13/SatID13</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID13</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID14</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID14/SatID14</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID14</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID15</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID15/SatID15</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID15</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID16</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID16/SatID16</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID16</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID17</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID17/SatID17</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID17</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID18/SatID18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID18</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID19</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID19/SatID19</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID19</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID2/SatID2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID20/SatID20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID20</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID3/SatID3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID4</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID4/SatID4</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID4</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID5</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID5/SatID5</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID5</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID6</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID6/SatID6</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID6</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID7</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID7/SatID7</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID7</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID8</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID8/SatID8</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID8</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID9</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID9/SatID9</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID9</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNoInAttitudeRTK</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNoInAttitudeRTK/SatNoInAttitudeRTK</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNoInAttitudeRTK</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNoInPositionRTK</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNoInPositionRTK/SatNoInPositionRTK</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNoInPositionRTK</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNum/SatNum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SeatOccptnNum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SeatOccptnNum/SeatOccptnNum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SeatOccptnNum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ShftSeqStat_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ShftSeqStat_enum/ShftSeqStat_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ShftSeqStat_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SideLghtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SideLghtSts/SideLghtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SideLghtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdAstCndStsCamr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdAstCndStsCamr/SpdAstCndStsCamr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdAstCndStsCamr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdAstSysTrgtSpd_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdAstSysTrgtSpd_IPD/SpdAstSysTrgtSpd_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdAstSysTrgtSpd_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLimitManualSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLimitManualSts/SpdLimitManualSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLimitManualSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtMdMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtMdMsgReq/SpdLmtMdMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtMdResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtMdResp/SpdLmtMdResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtNav/SpdLmtNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetNumReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumReq/SpdLmtOfstSetNumReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetNumReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetNumResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumResp/SpdLmtOfstSetNumResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetNumResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetPercReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercReq/SpdLmtOfstSetPercReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetPercReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetPercResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercResp/SpdLmtOfstSetPercResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetPercResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetReq/SpdLmtOfstSetReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetResp/SpdLmtOfstSetResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtPathRngNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtPathRngNav/SpdLmtPathRngNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtPathRngNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpedRegulaModSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpedRegulaModSwReq/SpedRegulaModSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpedRegulaModSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpedRegulaModSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpedRegulaModSwSts/SpedRegulaModSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpedRegulaModSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/StrtTypAvail_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/StrtTypAvail_enum/StrtTypAvail_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrtTypAvail_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SvGroup</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SvGroup/SvGroup</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SvGroup</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TASSAMTqSplt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TASSAMTqSplt_Nm/TASSAMTqSplt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TASSAMTqSplt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TASTMTqSplt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TASTMTqSplt_Nm/TASTMTqSplt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TASTMTqSplt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUIntvSAMTq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUIntvSAMTq_Nm/TCUIntvSAMTq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUIntvSAMTq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUIntvTMTq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUIntvTMTq_Nm/TCUIntvTMTq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUIntvTMTq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUOpSt_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUOpSt_enum/TCUOpSt_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUOpSt_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TDMAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TDMAvlbly/TDMAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDMAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TJAICAMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TJAICAMsgReq/TJAICAMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICAMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMdSwDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMdSwDspCmd/TLRMdSwDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMdSwDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMdSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMdSwReq/TLRMdSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMdSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMsgReq/TLRMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRSysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRSysSts/TLRSysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRSysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRWarning</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRWarning/TLRWarning</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRWarning</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSBtmNosRSSI</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSBtmNosRSSI/TPMSBtmNosRSSI</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSBtmNosRSSI</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrID/TPMSSnsrID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrIDLoctn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrIDLoctn/TPMSSnsrIDLoctn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrIDLoctn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRSSI</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRSSI/TPMSSnsrRSSI</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRSSI</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRdoFrqcCtr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtr/TPMSSnsrRdoFrqcCtr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRdoFrqcCtr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRdoFrqcCtrLoctn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtrLoctn/TPMSSnsrRdoFrqcCtrLoctn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRdoFrqcCtrLoctn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSWntrMdA</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSWntrMdA/TPMSWntrMdA</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSWntrMdA</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TQRTMTqReq_N</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TQRTMTqReq_N/TQRTMTqReq_N</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TQRTMTqReq_N</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TRCEMTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TRCEMTqReq_Nm/TRCEMTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TRCEMTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TRCTqDmdSTC_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TRCTqDmdSTC_Nm/TRCTqDmdSTC_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TRCTqDmdSTC_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSts/TSRSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSwReq/TSRSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSwReqResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSwReqResp/TSRSwReqResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSwReqResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRTrgtBanSign</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRTrgtBanSign/TSRTrgtBanSign</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRTrgtBanSign</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRTrgtWarnSign</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRTrgtWarnSign/TSRTrgtWarnSign</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRTrgtWarnSign</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TZXEMMaxTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TZXEMMaxTqReq_Nm/TZXEMMaxTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TZXEMMaxTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TZXEMTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TZXEMTqReq_Nm/TZXEMTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TZXEMTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TemSnsrHdwrFltPrst</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TemSnsrHdwrFltPrst/TemSnsrHdwrFltPrst</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TemSnsrHdwrFltPrst</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TgtParkingFavorite</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TgtParkingFavorite/TgtParkingFavorite</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TgtParkingFavorite</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ToEPSMsgChlg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ToEPSMsgChlg/ToEPSMsgChlg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ToEPSMsgChlg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TqCtrlStat_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TqCtrlStat_enum/TqCtrlStat_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TqCtrlStat_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnKeyBtnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnKeyBtnSts/TrdtnKeyBtnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnKeyBtnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyFindCarSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyFindCarSwSts/TrdtnSmrtKyFindCarSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyFindCarSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyLckSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLckSwSts/TrdtnSmrtKyLckSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyLckSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyLdspcSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLdspcSwSts/TrdtnSmrtKyLdspcSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyLdspcSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyUnlckSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyUnlckSwSts/TrdtnSmrtKyUnlckSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyUnlckSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfGreenLghtActn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfGreenLghtActn/TrfGreenLghtActn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfGreenLghtActn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcForbidDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcForbidDist/TrfcForbidDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcForbidDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcInfoSignDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcInfoSignDist/TrfcInfoSignDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcInfoSignDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcJamRngNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcJamRngNav/TrfcJamRngNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcJamRngNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtFuctionSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwReq/TrfcLghtFuctionSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtFuctionSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtFuctionSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwSts/TrfcLghtFuctionSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtFuctionSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcLghtStSp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtStSp/TrfcLghtStSp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcLghtStSp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdForbidDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdForbidDist/TrfcMrgdForbidDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdForbidDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdForbidSign</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdForbidSign/TrfcMrgdForbidSign</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdForbidSign</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdInfoSign</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSign/TrfcMrgdInfoSign</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdInfoSign</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdInfoSignDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSignDist/TrfcMrgdInfoSignDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdInfoSignDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdWrnngSign</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSign/TrfcMrgdWrnngSign</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdWrnngSign</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcMrgdWrnngSignDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSignDist/TrfcMrgdWrnngSignDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcMrgdWrnngSignDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrgtCndSpdReqCamr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrgtCndSpdReqCamr/TrgtCndSpdReqCamr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtCndSpdReqCamr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrgtSpdSrcSts_IPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrgtSpdSrcSts_IPD/TrgtSpdSrcSts_IPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrgtSpdSrcSts_IPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TripCnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TripCnt/TripCnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TripCnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TripCntResetReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TripCntResetReq/TripCntResetReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TripCntResetReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VDCSlipCtrlSts_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VDCSlipCtrlSts_enum/VDCSlipCtrlSts_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VDCSlipCtrlSts_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshDay</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshDay/VehTiPblshDay</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshDay</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshHr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshHr/VehTiPblshHr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshHr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshMins</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshMins/VehTiPblshMins</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshMins</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshMth</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshMth/VehTiPblshMth</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshMth</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshSec</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshSec/VehTiPblshSec</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshSec</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/VehTiPblshYear</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshYear/VehTiPblshYear</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehTiPblshYear</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Veldownsigma</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Veldownsigma/Veldownsigma</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Veldownsigma</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Veleastsigma</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Veleastsigma/Veleastsigma</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Veleastsigma</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Velnorthsigma</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Velnorthsigma/Velnorthsigma</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Velnorthsigma</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/WhlRghRoad</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/WhlRghRoad/WhlRghRoad</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlRghRoad</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/WhlRghRoadV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/WhlRghRoadV/WhlRghRoadV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/WhlRghRoadV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
              </DATA-MAPPINGS>
              <SW-MAPPINGS>
                <SWC-TO-ECU-MAPPING UUID="imex_a505a3f19f25843c4b54f570_a505a3f19f25843c4b54f56f">
                  <SHORT-NAME>Mapping_FVCM_FVCM</SHORT-NAME>
                  <COMPONENT-IREFS>
                    <COMPONENT-IREF>
                      <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</TARGET-COMPONENT-REF>
                    </COMPONENT-IREF>
                  </COMPONENT-IREFS>
                  <ECU-INSTANCE-REF DEST="ECU-INSTANCE">/Topology/HardwareComponents/IPD</ECU-INSTANCE-REF>
                </SWC-TO-ECU-MAPPING>
              </SW-MAPPINGS>
            </SYSTEM-MAPPING>
          </MAPPINGS>
          <ROOT-SOFTWARE-COMPOSITIONS>
            <ROOT-SW-COMPOSITION-PROTOTYPE UUID="Oa505a3f19f25843c4b4019ccXOa505a3f19f25843c4b4019cb00">
              <SHORT-NAME>IPDEcuComp</SHORT-NAME>
              <SOFTWARE-COMPOSITION-TREF DEST="COMPOSITION-SW-COMPONENT-TYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp</SOFTWARE-COMPOSITION-TREF>
            </ROOT-SW-COMPOSITION-PROTOTYPE>
          </ROOT-SOFTWARE-COMPOSITIONS>
        </SYSTEM>
      </ELEMENTS>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="a82bbac4bcec343fb0d3e9e440568343">
      <SHORT-NAME>Topology</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3e64cef7b926303db1927aad78faa370">
          <SHORT-NAME>Clusters</SHORT-NAME>
          <ELEMENTS>
            <CAN-CLUSTER UUID="Oa505a3f19f25843c4b3f8920XOa505a3f19f25843c4b3f891f00">
              <SHORT-NAME>BKPCANFD</SHORT-NAME>
              <CAN-CLUSTER-VARIANTS>
                <CAN-CLUSTER-CONDITIONAL>
                  <BAUDRATE>500000</BAUDRATE>
                  <PHYSICAL-CHANNELS>
                    <CAN-PHYSICAL-CHANNEL UUID="Oa505a3f19f25843c4b3f8933XOa505a3f19f25843c4b3f893200">
                      <SHORT-NAME>BKPCANFD</SHORT-NAME>
                      <COMM-CONNECTORS>
                        <COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                          <COMMUNICATION-CONNECTOR-REF DEST="CAN-COMMUNICATION-CONNECTOR">/Topology/HardwareComponents/IPD/IPD_BKPCANFD</COMMUNICATION-CONNECTOR-REF>
                        </COMMUNICATION-CONNECTOR-REF-CONDITIONAL>
                      </COMM-CONNECTORS>
                      <FRAME-TRIGGERINGS>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c261100">
                          <SHORT-NAME>BCM_BDCAN_100ms_FrP41</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BCM_BDCAN_100ms_FrP41_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/BCM_BDCAN_100ms_FrP41</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/BCM_100ms_PDU41</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>882</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2ac900">
                          <SHORT-NAME>DIAG_DTCInfo_ICBAD</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DIAG_DTCInfo_ICBAD_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/DIAG_DTCInfo_ICBAD</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DIAG_DTCInfo_ICBAD1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1949</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c173f00">
                          <SHORT-NAME>DKMM_LHBDCANFD_Event_FrS03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DKMM_LHBDCANFD_Event_FrS03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/DKMM_LHBDCANFD_Event_FrS03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/DKMM_Sporadic_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1319</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c13c500">
                          <SHORT-NAME>Diag_BKPCANFD_FuncReq_BKPCANFD</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Diag_BKPCANFD_FuncReq_BKPCANFD_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/Diag_BKPCANFD_FuncReq</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Diag_BKPCANFD_FuncReq_BKPCANFD1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>2015</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c14b900">
                          <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD_BKPCANFD</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Diag_BKPCANFD_PhyReq_IPD_BKPCANFD_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/Diag_BKPCANFD_PhyReq_IPD</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Diag_BKPCANFD_PhyReq_IPD_BKPCANFD1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1845</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c14df00">
                          <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD_BKPCANFD</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Diag_BKPCANFD_PhyResp_IPD_BKPCANFD_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/Diag_BKPCANFD_PhyResp_IPD</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Diag_BKPCANFD_PhyResp_IPD_BKPCANFD1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1853</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c141900">
                          <SHORT-NAME>FDR_BKPCANFD_100ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_BKPCANFD_100ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FDR_BKPCANFD_100ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FDR_100ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>898</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c148b00">
                          <SHORT-NAME>FDR_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FDR_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_FDR</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1254</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c10eb00">
                          <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_BKPCANFD_100ms_FrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FVCM_BKPCANFD_100ms_FrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FVCM_100ms_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>958</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c302d00">
                          <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP05</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_BKPCANFD_100ms_FrP05_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FVCM_BKPCANFD_100ms_FrP05</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FVCM_100ms_PDU05</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>956</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2d1500">
                          <SHORT-NAME>FVCM_BKPCANFD_20ms_FrP02</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_BKPCANFD_20ms_FrP02_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/FVCM_BKPCANFD_20ms_FrP02</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/FVCM_20ms_PDU02</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>307</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c195300">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP49</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP49_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP49</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU49</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1381</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c197900">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP55</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP55_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP55</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU55</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1374</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c199f00">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP58</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP58_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP58</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU58</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1375</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c19c500">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP59</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP59_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP59</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU59</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1382</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c19eb00">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP60</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP60_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP60</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU60</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1383</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1a1100">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP61</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP61_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP61</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU61</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1384</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1a3700">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP62</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP62_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP62</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU62</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1385</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1a5d00">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP63</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP63_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP63</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU63</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1386</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1a8300">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP64</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP64_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP64</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU64</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1387</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1aa900">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP65</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP65_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP65</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU65</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1388</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1acf00">
                          <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP66</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_BKPCANFD_1000ms_FrP66_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_BKPCANFD_1000ms_FrP66</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_1000ms_PDU66</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1380</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c176500">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1082</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c17b100">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP06</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP06_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP06</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU06</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>766</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c17d700">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP07</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP07_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP07</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU07</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>335</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3239f00">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP08</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP08_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP08</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU08</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>887</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3254100">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP34</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP34_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP34</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU34</PDU-TRIGGERING-REF>
