              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinLclSwtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf375cd1e95e3b1bbe813c17808f1f15">
              <SHORT-NAME>RRWinMotFlt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinMotFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f24d90c95b25336fbb6a29a3ff5c3efd">
              <SHORT-NAME>RRWinMotSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinMotSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b8d3bc97bcb33e1a8ed94b9258067770">
              <SHORT-NAME>RRWinShrtDwnSucd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RRWinShrtDwnSucd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93b4690fc6653192a3be8220eb2eb1cd">
              <SHORT-NAME>RVSEPTRdy</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSEPTRdy</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a9501abbf0b734c2b6bd56199c8e508e">
              <SHORT-NAME>RVSEnRunning</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSEnRunning</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95e8e0d1d00a38b398ed2922ce987ea4">
              <SHORT-NAME>RVSPtCrkAbotd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtCrkAbotd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d93077ddb2c3b5fb905d36a997289ee">
              <SHORT-NAME>RVSPtCrkAbotdRsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtCrkAbotdRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d665898b52cd30608f9cd341afde8fc0">
              <SHORT-NAME>RVSPtRunAbotd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtRunAbotd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02c340b66f763c5991b8b8e694f283c0">
              <SHORT-NAME>RVSPtRunAbotdRsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RVSPtRunAbotdRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9fc76f4ef4563e5a9a4ebcd8d166dc3e">
              <SHORT-NAME>RZCUIgnDiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUIgnDiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6e4dedeebc5e3846bb193dc63b213b7d">
              <SHORT-NAME>RZCUIgnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUIgnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd52258c9e5435feb4551579c715315a">
              <SHORT-NAME>RZCU_100ms_Group10_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3d3abd81ea1d35f385214cdc9ed1e204">
              <SHORT-NAME>RZCU_100ms_Group10_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47e7e42b85bc33a8a5b6e5e402a6b9eb">
              <SHORT-NAME>RZCU_100ms_Group10_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce7c84c7c1c634939a39229dcb631918">
              <SHORT-NAME>RZCU_100ms_Group10_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9455577afecd32a98b359d3d63b10eec">
              <SHORT-NAME>RZCU_100ms_Group10_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a05f6074b0f73918bac0fac42eb12bf2">
              <SHORT-NAME>RZCU_100ms_Group10_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dfb3b43a64073e67aafc0bc6899628c1">
              <SHORT-NAME>RZCU_100ms_Group10_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_100ms_Group10_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf7f2b2ed2c7370ead5946d3c15bde80">
              <SHORT-NAME>RZCU_10ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc9674aceddd32a4bdda76a8dc5cedc8">
              <SHORT-NAME>RZCU_10ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c6a6e24c7163da08e34d032ff3596e4">
              <SHORT-NAME>RZCU_10ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aae40b217a263fce807188037b7db33f">
              <SHORT-NAME>RZCU_10ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32ac7b591ac639e7889424507ef37456">
              <SHORT-NAME>RZCU_10ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8772d0c7bdcb3dbda15f0b4d19bc1b66">
              <SHORT-NAME>RZCU_10ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="188d28449ccb3e90bf41ea5ac2e400b7">
              <SHORT-NAME>RZCU_10ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="318f75384fad373d994c12bfd3f688a5">
              <SHORT-NAME>RZCU_10ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="879106671922349eb6e2abf838ff0343">
              <SHORT-NAME>RZCU_10ms_Group22_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13483df2e846342b83703356f14525db">
              <SHORT-NAME>RZCU_10ms_Group22_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb8a3ded578b3ec9954eb59109c6ab61">
              <SHORT-NAME>RZCU_10ms_Group22_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78136664097838d8b547c1975c8790a4">
              <SHORT-NAME>RZCU_10ms_Group22_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group22_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f707afcd3a5344eb6f57ee1c01bd1f7">
              <SHORT-NAME>RZCU_10ms_Group23_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b10b75bf982d379f92d679af0ddfdf8c">
              <SHORT-NAME>RZCU_10ms_Group23_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52405a06fb363657abaf1775ebcf3c8e">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f2ed339ac6e3d33931aefa4defbd2ab">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59db178b71eb3af28bc44e8eb90fbd13">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8dacba9f530c337588c136d02df3b357">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fad901a82be9389389279447f390e316">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="40acf629726b34ec8f7c0e2344f9ae22">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bbf8f6e38f4335058c1a0a0a06b6ae13">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="77fb275b179f32e8aee9f069279b5da1">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52a0e99c45453aef8a1700a7d335806d">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="60b06ce486293c339c1b3a7790b9c1f0">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="89e4c1c0bd66369badea579b0d339ada">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a28484019ed3e119c2001a2eb938304">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="373c657889e63d348e4fdbba33001a91">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a0d7324aeb0f321aae2b398c2de89ed6">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f3685fdc92c3f56b4f4f8eae7ca2cb1">
              <SHORT-NAME>RZCU_10ms_Group23_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group23_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e441a74dbb3d3c868e5f132ff978b2d9">
              <SHORT-NAME>RZCU_10ms_Group24_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ae71b72e232f3e039626a425879c6e3a">
              <SHORT-NAME>RZCU_10ms_Group24_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="09389980e42b362ebac8c4de78f31f60">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="904ae265933331f993f4ec56f0e2cef9">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31c19061597734f3a05318cf8414e90c">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="022fcf9a0de934219aed367201fb07f9">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5cfe4d1e9f6233378c22a64e353a92e7">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed04e526546f3bd48d2ec7ff1d7edc08">
              <SHORT-NAME>RZCU_10ms_Group24_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group24_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea382510b4dc39aab28b242bac33df3f">
              <SHORT-NAME>RZCU_10ms_Group90_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6457149d0883375691df7b7bdc966a8b">
              <SHORT-NAME>RZCU_10ms_Group90_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3bb6e45b618f3bcfb3e7f4ef71baedd4">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02b51598abc43f7999be4018a1be4701">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e29e112a393133cf8973190ef9b17fbd">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="820d32bc285d3e2db2522fc10797c974">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1cb56e1ad33a3892a36e2ef5d1350814">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved135</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved135</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="98c4c39d2b1c3bf1bcb86151644c5544">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved143</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved143</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec1bd85ee00931718d5da5533fe01ae0">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb2a9e0bd4b538b6a026ab1ed3e5eb83">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved151</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved151</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea699c57e344312b90c0db8af77af5bc">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved159</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved159</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91da1d263d193bf5acea390ad1bbc7e8">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b1169533d653ddca0e465a0a7b88a34">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="016e629f2e2730e1b19be5568662d8d6">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="440dc28c610c32d1a81b88a9a950ca92">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="14a10518636139eb9dc07129f70b1733">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a3a5062dc01d3ae085bcdfb7d4762f53">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5db61ec53db5351db1c0bdd9e9c50905">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="052f561e234837e5be9f0ba5dc772194">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="311ba6bf598532dda5158e2a079269b3">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved83</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved83</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3d96dff1205035c4af6f8f57c43f9705">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved87</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21079670ca9f353e932693113159435b">
              <SHORT-NAME>RZCU_10ms_Group90_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_10ms_Group90_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e6acb9dfc81b3f109c1d53a350c813d1">
              <SHORT-NAME>RZCU_20ms_Group06_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d2f4b00291e3326886a0562baa37168a">
              <SHORT-NAME>RZCU_20ms_Group06_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="782ba0df7f623ca7a91e2632fd0b9743">
              <SHORT-NAME>RZCU_20ms_Group06_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="535fb2ae7d73394fa2ca2526b989b2d3">
              <SHORT-NAME>RZCU_20ms_Group06_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b5ccf3ef5c073acda562b9652effa471">
              <SHORT-NAME>RZCU_20ms_Group06_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f8032de082543c0b864693c0c30a571b">
              <SHORT-NAME>RZCU_20ms_Group06_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f4ab4f293f8a3e07b04840c0ee2e3472">
              <SHORT-NAME>RZCU_20ms_Group06_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_20ms_Group06_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02238c5848ac3177845fd54f978acf09">
              <SHORT-NAME>RZCU_50ms_Group37_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d62099d8b3b3ef497b403e91fb2ca9a">
              <SHORT-NAME>RZCU_50ms_Group37_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4a78f4369b13346198a6301bb5ae9b57">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4963252748243548ba9f02d13bf49a37">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="890f4ac0f6163a4a83c88f9b5f378731">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee794b74f2da395e81a0e8d024961d23">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved34</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved34</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4358874849943821b35f0b2879477f81">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved36</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved36</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="913cf108924d313080a9abf3274f21b5">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved38</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved38</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94f40f9f41d632fab9f8fd207150968c">
              <SHORT-NAME>RZCU_50ms_Group37_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_50ms_Group37_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8caaf4a6bcb396da5b03d89fe7e1a24">
              <SHORT-NAME>RZCU_BKBCANFDAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_BKBCANFDAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f828e112eea7378db2df59c69ff0a051">
              <SHORT-NAME>RZCU_NKI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f39d6952057a30d487d09401582a2d1b">
              <SHORT-NAME>RZCU_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="15db68d46d02380f91cd03940a9eb165">
              <SHORT-NAME>RZCU_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e5e7bb8e408838b08147cae031e88e39">
              <SHORT-NAME>RZCU_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3200aa000cf3bb3a5c5c539603efb7f">
              <SHORT-NAME>RZCU_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="955231a4368d3b11917b8eb668db82d3">
              <SHORT-NAME>RZCU_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2d65b60b395931b088061587726e4d47">
              <SHORT-NAME>RZCU_NM_NOSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="967debc7d7493b7d9e9ec6922d947811">
              <SHORT-NAME>RZCU_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4345df03c70394582a42f2e6545459d">
              <SHORT-NAME>RZCU_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46fbbf0c02593ca282ffcd16e47d7547">
              <SHORT-NAME>RZCU_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1867fdc94a9f38cfbb7324651717278e">
              <SHORT-NAME>RZCU_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e0cbaf833223ad9aa0bd0c5bd692da4">
              <SHORT-NAME>RZCU_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f15e5a3ccd2319590c9797d718b3b11">
              <SHORT-NAME>RZCU_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="254c1b7cc9eb33ab8e06c1c27ec8c59d">
              <SHORT-NAME>RZCU_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a8912e8bc85631fa8fed021caf8ab5d2">
              <SHORT-NAME>RZCU_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="45f24fd9495934c7b1a948a3329e661b">
              <SHORT-NAME>RZCU_NM_RMSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1593277b75d33ab9b3cb3efb645ced66">
              <SHORT-NAME>RZCU_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3447002322d739f9b1b9c2f256bb5851">
              <SHORT-NAME>RZCU_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3ab78aa984338dab3ca4902374dda55">
              <SHORT-NAME>RZCU_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca238040b4f735c3a36249b8e44065b3">
              <SHORT-NAME>RZCU_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db02fc3262eb3cfd8a2d5f9fbf212d75">
              <SHORT-NAME>RZCU_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb25696f0750345c86137d7c690e28f7">
              <SHORT-NAME>RZCU_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3dbb345613d0333c8f87e96a2c555f67">
              <SHORT-NAME>RZCU_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2958aa86ec1d3ac892aea2207e90aa67">
              <SHORT-NAME>RZCU_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b93106331b593c11a0f56d570de15a31">
              <SHORT-NAME>RZCU_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51d597cf502c3302bf67282cdc907fc1">
              <SHORT-NAME>RZCU_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d733635b6961355ba501f322c656eb34">
              <SHORT-NAME>RZCU_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="efba779dd10132a3802a84db10b4f830">
              <SHORT-NAME>RZCU_NOI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="037993046ce83890bba42e4c8159498d">
              <SHORT-NAME>RZCU_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="04698ca7bab23665ba0c257054c84bce">
              <SHORT-NAME>RZCU_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52b628bbd96e3917a841425e8fc1ae5d">
              <SHORT-NAME>RZCU_NWI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbaa4d2fccff33f5b411e70e049bf277">
              <SHORT-NAME>RZCU_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="22993a295d093ca29910f07e93309610">
              <SHORT-NAME>RZCU_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="678a4e75ede73521a1647225e7f28f45">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29278861e8ac336eb7a7de408d425799">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="00e3e9abb4b13c4c83cf751bf43f3b62">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="74b612110fc736e4b7edc207e8ecda25">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46f0926a55073b9da5f74fa5f078aa4e">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2589de304fd239258761c765da3969f0">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e0f3cbdcc4336cf91145df599a1d20e">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="979013f412b43c62bd80977cc3b5b03d">
              <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCU_ZONE_10ms_Group64_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="87d5cd742ea834899119a259cd22774a">
              <SHORT-NAME>RZCUeFs1DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs1DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="770268b79de3340f8df8994d90e983e4">
              <SHORT-NAME>RZCUeFs1Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs1Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ecd712daf6b53daeb4ca25228ddb509c">
              <SHORT-NAME>RZCUeFs2DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs2DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fee884bff6c73e0ebdac6ac99a9139c5">
              <SHORT-NAME>RZCUeFs2Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs2Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc804a522e8437a49b30d904fe31fa12">
              <SHORT-NAME>RZCUeFs3DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs3DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e24ed485055392e8f516334cdb08ab4">
              <SHORT-NAME>RZCUeFs3Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeFs3Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb5dfc00f18d3f1c9d6b3ed78467ad18">
              <SHORT-NAME>RZCUeSw10DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw10DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8de22a8af38832adbd09105fa51d1389">
              <SHORT-NAME>RZCUeSw10Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw10Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="453a9f663c1e3a8084b43d03e6d952e8">
              <SHORT-NAME>RZCUeSw9DiagSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw9DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91e7fd67e90d30e899e055c138d11f77">
              <SHORT-NAME>RZCUeSw9Sts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw9Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e193afe0542b31daa7ac87e597bfdc98">
              <SHORT-NAME>RainClsWndAppMsg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RainClsWndAppMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4338fff1f7383107821bed941a152573">
              <SHORT-NAME>RdundtHybCmddEnToqImmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqImmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d459b599ad9337f5bc13a91ee4f918c1">
              <SHORT-NAME>RdundtHybCmddEnToqPrdtd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqPrdtd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32570df7e71331b3a6976f4092eb17c5">
              <SHORT-NAME>RdundtHybCmddEnToqRespTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqRespTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dd613cc7959339409c482785c82e6a2d">
              <SHORT-NAME>ReAxleMaxAvlblWhlDrvTq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlDrvTq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8909035eaa363e939ed042f38b07dea6">
              <SHORT-NAME>ReAxleMaxAvlblWhlDrvTqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlDrvTqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a02a759012431c5b9e77efaa975efdc">
              <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlRgtnTq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b0fb396d9f7032ffba62ba05ef774512">
              <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlRgtnTqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a504c66e2ce938e18dbf9c18f3c800b4">
              <SHORT-NAME>RearFogLghtFltsts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RearFogLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b858f6b78bc36c9bd7ff2bb95237259">
              <SHORT-NAME>RearFogLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RearFogLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06aa019fbdc238e0a51079660319d16c">
              <SHORT-NAME>ResetCnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ResetCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f0a70a45f2e63b8ba4f555c48508d57b">
              <SHORT-NAME>RevsLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f641b3c74e837f8b24022ec7e2af956">
              <SHORT-NAME>RevsLghtF_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e234e96f858837fcb1ab16f268c5a046">
              <SHORT-NAME>RevsLghtFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="edc06908ee3736fab592235b2d6a990c">
              <SHORT-NAME>RevsLghtOn_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtOn_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee0d10e7129f32d4b22fae3f92f92c71">
              <SHORT-NAME>RevsLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4c02b8eb7f733c8baaccd549639cac9">
              <SHORT-NAME>RgnLvReqFICM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgnLvReqFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="40954ab4c9413f0faac316ae49c3afc0">
              <SHORT-NAME>RgnLvReqFICMV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgnLvReqFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="92b19fad14f63642ac13003306032393">
              <SHORT-NAME>RgtvBrkFnFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgtvBrkFnFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b49d3cc16cf3a3a824e2b416423dd31">
              <SHORT-NAME>RgtvBrkFnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgtvBrkFnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ecb6d14baec34118de3832047051fee">
              <SHORT-NAME>RightEyeOccludeStatus_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RightEyeOccludeStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="480f310d9dae37e294050da2b645f30f">
              <SHORT-NAME>RmtDrvrTrgtEPSStrgWhlAng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtDrvrTrgtEPSStrgWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="153258a862c231a5948052380fa452be">
              <SHORT-NAME>RmtParkngAstAbotBtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstAbotBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cda4f29c47943d5a92f2097764fd13ce">
              <SHORT-NAME>RmtParkngAstBtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79281ff2739530cdbdf2f3e72fd0a8a0">
              <SHORT-NAME>RmtParkngAstDvcFlrRsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstDvcFlrRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61ff50b7c14837dabcdb1109ca94ddee">
              <SHORT-NAME>RmtParkngAstDvcSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstDvcSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75185e676d2b374da0103422db3b0b68">
              <SHORT-NAME>RmtParkngAstParkngOutDircnSeln</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstParkngOutDircnSeln</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4301e8371c783e34be65cf6b80b9f0b0">
              <SHORT-NAME>RoadCrvt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadCrvt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c5b503a80aa3a2ba148fd3789c8fa6d">
              <SHORT-NAME>RoadCrvtDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadCrvtDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="26bff9ba79de333688a58fae6e5ed970">
              <SHORT-NAME>RoadHeightL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadHeightL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3e0976ae32a53d22891bc23b14bfea3b">
              <SHORT-NAME>RoadHeightR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadHeightR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7386d4e6434b31c181b847fb1dc770ce">
              <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2515b79cad4733e8b2480e55ee65c93c">
              <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c231dd0de45c301fb00da75d2940709d">
              <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="723573d186d13637a255b436ed29f48f">
              <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="76e365f404073f59998e44248e6bc8b2">
              <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5ef759c9caf230e08a842853bd205a9c">
              <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e334523d69b432bf903837f9c1264328">
              <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="918002d82d2b34dea62ff6e7a3419dc0">
              <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="12463dc089313d27a404ae6d99aff278">
              <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93667aa259143227a7c4f8bf612276fd">
              <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f128622a180a31b09b9fb6e6024c4be8">
              <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ed7003e8f8f3f049cc451f3caa1860e">
              <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c5dc04b3b98a346b90a7ff21c1c5f738">
              <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcbef301947e3811920bf1d56123e16b">
              <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e577fc1a0743546be3b7d22611b2c1e">
              <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="00370df15bfc346589556417da354912">
              <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c86c6435bed73b06b86acc69a82196b4">
              <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58b02a499d95368a90c5f50e7090de99">
              <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6ab385c741b3437aeb144a323a2b652">
              <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc32d7bc9db23b65a318afddd0495fc1">
              <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="66580b83787132d58a519c2cfd040a70">
              <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec64f0aff762389aa9c86597a1a9a8bc">
              <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6d71db371f8637ecb4864a967eef2108">
              <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cee4547b370f3a44b6b519aec70bb69e">
              <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee866a09b79e36159576233bc2b3e0ed">
              <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="754b82027d273cf4ab34037586d425ee">
              <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5bc0fea2328a369295fb3af26750452e">
              <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b2807baa1743851a977b60eb8141848">
              <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b727be7e183349393ef4f736c33bdb5">
              <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79392c08b00b3e1ca1ec3429a890f1d4">
              <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95dbb5fc667c3a6c97e125b46d5a91fa">
              <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockLevelL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="982bd1d2ce323a269d6afd3d54b5d8fb">
              <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockLevelR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94b621eca99934f7a5a02f3edc221476">
              <SHORT-NAME>RoadSlope</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadSlope</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75b465fa3cb631e79b07ff4b33cd79d3">
              <SHORT-NAME>RoadSlopeDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadSlopeDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de02fc9d1c8b3eaeabeae76c723d2215">
              <SHORT-NAME>Rolloff2Min_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Rolloff2Min_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47f40d79a1c43b5794f46876bef5c4ec">
              <SHORT-NAME>RolloffHld_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RolloffHld_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="574a72a080793e6fb10784e9e4752639">
              <SHORT-NAME>RoughRoaddetection</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoughRoaddetection</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="38c084fc7b3a3cbf9f226c2f361abc80">
              <SHORT-NAME>RoughRoaddetectionDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoughRoaddetectionDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47495e18111d3e14962fd77ccb2a67a9">
              <SHORT-NAME>RrAxleActuWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrAxleActuWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ee0b6da5ebf3b88894552387eefcd87">
              <SHORT-NAME>RrAxleActuWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrAxleActuWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91ebc4b6c10131469e3e57bf9c1447b0">
              <SHORT-NAME>RrBmpAntFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrBmpAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d7519b1e73a320d97925542ba2a6046">
              <SHORT-NAME>RrCrnRdrCalSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrCrnRdrCalSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="92962a30bf7f3d76a7147e6086153155">
              <SHORT-NAME>RrFogLghtF_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8b13797e9633ec5baa34661d82d1ac6">
              <SHORT-NAME>RrFogLghtOn_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLghtOn_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d75a60d73193d9c957c354215613a2a">
              <SHORT-NAME>RrFogLightOnReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLightOnReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e10fddd3b423974bdabd32febadbf2e">
              <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrMidLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a47bb846fb1b34738d352856f6245e4c">
              <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrMidRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="23fb912020cc34d092b31709d8be3398">
              <SHORT-NAME>RrObsDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrObsDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69fb83ddbe84356b95e9d6826b22aa48">
              <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrPDCAudWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ad65d3e9425334bbc9686e0b2678580">
              <SHORT-NAME>RrPDCPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrPDCPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db49588b11273231bf943fb1bd01c1e4">
              <SHORT-NAME>RrSrvcPosReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSrvcPosReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f2ba2de6d953453b366d4221875bfaf">
              <SHORT-NAME>RrSsdAppCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSsdAppCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="45b92e819cb032ed835cc55f87e43020">
              <SHORT-NAME>RrSsdPosCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSsdPosCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ea63ea34cec30af87e515792cc710b3">
              <SHORT-NAME>RrTireStdPrs</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrTireStdPrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5b33a7acda239deae4adcc9ffa508f2">
              <SHORT-NAME>RrWiperFnEnb</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrWiperFnEnb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4cab7d521c3633378beeeaaf973079bc">
              <SHORT-NAME>RrWiperReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrWiperReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b407502a3f4354d9d61efe68f452d14">
              <SHORT-NAME>RstrFctryDeftsReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RstrFctryDeftsReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="616bd5d200d03eb2b6f5e6bec451971c">
              <SHORT-NAME>SACPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SACPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7db1b5afed103497963e2fb6c1628b64">
              <SHORT-NAME>SAC_ExtdAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a32112d4f743446a4a1cf32b09b06d2">
              <SHORT-NAME>SAC_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6cda48c04ac93c819b1cd05c106f8d1e">
              <SHORT-NAME>SAC_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba26d3ed80b732f69f646d0f01b6f8bb">
              <SHORT-NAME>SAC_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6de72b290ee039138bb675ad07319afb">
              <SHORT-NAME>SAC_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b81028c40f703d92a659ffd0bbe88cc2">
              <SHORT-NAME>SAC_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ddcac346843f34df9715dfd74404b6b2">
              <SHORT-NAME>SAC_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4468feb6b1a83b1485dfd306310c8a2d">
              <SHORT-NAME>SAC_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca948c8d92073e40871318c686821bb2">
              <SHORT-NAME>SAC_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c09fb877e1634d4a1bf6ea5f0175c61">
              <SHORT-NAME>SAC_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab966406d27c3bcbacc146d6725f6eff">
              <SHORT-NAME>SAC_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="36b2073227ff3c9a95da9245fd355657">
              <SHORT-NAME>SAC_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc78e052267c350c842d165c25446c69">
              <SHORT-NAME>SAC_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3142a7ecb1d93023ae6199e57133a131">
              <SHORT-NAME>SASAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SASAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2eff8811f4ba37629ad1d7a1f38e31c9">
              <SHORT-NAME>SCSAPAAcclA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAPAAcclA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a0519528a953389ab530e6ceef5e65f4">
              <SHORT-NAME>SCSAPAAcclAV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAPAAcclAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de7ab95c12453599aed31f8c874d5e3a">
              <SHORT-NAME>SCSAutodDrvngSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAutodDrvngSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bf1918436e53cf7b80771974369ca42">
              <SHORT-NAME>SCSAutodDrvngSysStsV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAutodDrvngSysStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b7c71956f363bdb86de5c70bef3980b">
              <SHORT-NAME>SCSMdSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b47856f98393b75adb4b2203085e317">
              <SHORT-NAME>SCSVehHoldA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSVehHoldA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1c74f737f633ebd9cc416475d5465a6">
              <SHORT-NAME>SCSVehHoldAV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSVehHoldAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6d2d16387203b7e9f1b8353f0c54793">
              <SHORT-NAME>SCUAPAUnderCtrlA_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUAPAUnderCtrlA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f109e3592133cc7b7646e6cd0b1da5c">
              <SHORT-NAME>SCUAPAUnderCtrlActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUAPAUnderCtrlActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="382a80aca9c73a74be64d7fe2e692ff7">
              <SHORT-NAME>SCUActrMvmntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUActrMvmntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5cd6cd7fd893eba847b3b74926ff1a7">
              <SHORT-NAME>SCUDrvMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6f6f914956803abdaabc5be3dd7ffa81">
              <SHORT-NAME>SCUDrvnIntrvnPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvnIntrvnPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1dff91ff3a33c51aa295efa6549b079">
              <SHORT-NAME>SCUDrvrIntrvnA_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvrIntrvnA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4650661eaa3368ca293cdf717408cfc">
              <SHORT-NAME>SCUDrvrIntrvnActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvrIntrvnActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6db889f067c23bcb90a8af32e8b95a35">
              <SHORT-NAME>SCUExtdShifterActrPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUExtdShifterActrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab41be041eb5396a9aaf3fbf101f8b83">
              <SHORT-NAME>SCUExtdShiftrFlr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUExtdShiftrFlr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5274309acf10353d91082698e8c1332a">
              <SHORT-NAME>SCUFltLvlWarn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUFltLvlWarn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da0a748ff292366c822eb65d6f3834bb">
              <SHORT-NAME>SCUParkActrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkActrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69ffc1154a3d3d8181fcda433eab4bf2">
              <SHORT-NAME>SCUParkLckReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8ef0779a6903b7d8159a927966df0cc">
              <SHORT-NAME>SCUParkLckReqEPMCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqEPMCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e293eb0e07b3660964365d2b699b2c8">
              <SHORT-NAME>SCUParkLckReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fa6201e3a1d734ad9af05318a853f6e9">
              <SHORT-NAME>SCUParkLckReqVEPMCU</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqVEPMCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c3f77b0b0edd3ed194ee63ea9225efff">
              <SHORT-NAME>SCUShftLvrPosIncnstntFlag</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShftLvrPosIncnstntFlag</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ff349aff422f3612aece6c12dfdb1c31">
              <SHORT-NAME>SCUShftLvrPosTrgt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShftLvrPosTrgt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bbeea93529c83557a3e24ed622b38c78">
              <SHORT-NAME>SCUShiftrLvrPosn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrPosn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2c1b44e0def63d0a90340e291b6b580e">
              <SHORT-NAME>SCUShiftrLvrPosnLtchActv</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrPosnLtchActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a2b81f3fa62d383ca4beec71d868b724">
              <SHORT-NAME>SCUShiftrLvrRawPosn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrRawPosn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a4cf458700031c3b6704e31d2e57926">
              <SHORT-NAME>SCUShiftrOpngRmndr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrOpngRmndr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9716e52d274f33a48d668306cb42931c">
              <SHORT-NAME>SCUShiftrPosnInvsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrPosnInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b335088ce30130689594cb8a3fda9c18">
              <SHORT-NAME>SCUTapUpDwnSwSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUTapUpDwnSwSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dad2bd194bf23e4eadcce87c0464918e">
              <SHORT-NAME>SCUTapUpDwnSwStaInvsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUTapUpDwnSwStaInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dca9c02b9f9e37338dba9b9bd3ec3f66">
              <SHORT-NAME>SDMAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a6c11a188a534eda0cc12c3beef5b40">
              <SHORT-NAME>SDMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcfde001474e3806ab7a2c654e2e6a76">
              <SHORT-NAME>SDM_20ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1f954e4a22e3f9c9dd3cbf5a31df384">
              <SHORT-NAME>SDM_20ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5dff8391ba463c40bb466a84f03bf245">
              <SHORT-NAME>SDM_20ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc216c508d7d34a7949220a5fde0ed25">
              <SHORT-NAME>SDM_20ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e5c002e43f43cf6ad9c751ee56e6ed8">
              <SHORT-NAME>SDM_20ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="813f5062da0e38548f5c861d1f35e80f">
              <SHORT-NAME>SDM_20ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dec461ce23b93b61b0d6413620d488af">
              <SHORT-NAME>SDM_20ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="765504c21dc937bf9b60aeb843d473f5">
              <SHORT-NAME>SDM_20ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d6cdc2ebe58e3a70ad24b34c61153e07">
              <SHORT-NAME>SDM_20ms_Group02_Reserved16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bdee955b4255333e88f6bb687d22e66c">
              <SHORT-NAME>SDM_20ms_Group02_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b7d88849cb434f0aac7108f29556c2e">
              <SHORT-NAME>SDM_20ms_Group02_Reserved37</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved37</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="60706a15653834599b539702f3baf0eb">
              <SHORT-NAME>SDM_20ms_Group02_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c3c0feafa7693708831b05d8036483f4">
              <SHORT-NAME>SDM_20ms_Group02_Reserved51</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved51</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="71fc0e87ed0b3d348d110490784f23e0">
              <SHORT-NAME>SDM_20ms_Group02_Reserved57</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved57</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b403f2480a935618733cab89c95b93a">
              <SHORT-NAME>SDM_20ms_Group02_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c57c894ca8103d3eaa106c44bd4602e8">
              <SHORT-NAME>SDM_20ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db2e417a320339bfaf12336873dacb24">
              <SHORT-NAME>SDM_20ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5351894a63e0334e910780291c1b3848">
              <SHORT-NAME>SDM_20ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a1c6c27122b3d299378f3e3187109ac">
              <SHORT-NAME>SDM_20ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d62929dcfed034e4b88b25bd2795cfeb">
              <SHORT-NAME>SDM_20ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="399b6f389bba3449b8b9386d84b25d70">
              <SHORT-NAME>SDM_20ms_Group03_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24ec141f932737d88b3b1b1a391aaf83">
              <SHORT-NAME>SDM_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="30c2ff8385793b4fb26403eed47d2bd9">
              <SHORT-NAME>SDM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f671567406c36b389d609466a329c10">
              <SHORT-NAME>SDM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08711d4065973c04a10f4ff38402a40b">
              <SHORT-NAME>SDM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21139efcf64836f68839fa9cea829d6c">
              <SHORT-NAME>SDM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab9124581b8834b7bc3baa999420f40f">
              <SHORT-NAME>SDM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea956d3e526b370289057d936a8c892f">
              <SHORT-NAME>SDM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9a31d96da98a3e9f9e6aa663a0d3cb75">
              <SHORT-NAME>SDM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c6ab1c1b7f339789bf510664a2f5cdc">
              <SHORT-NAME>SDM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="971f7db775713428a7acdd94629b5cec">
              <SHORT-NAME>SDM_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4faff4276cb63af082f4d9bfc80315dc">
              <SHORT-NAME>SDM_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a2e08d74af2322b98b6b3a2537b2b7e">
              <SHORT-NAME>SDWLSFObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWLSFObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0892456084bf382081dbb28ff094d508">
              <SHORT-NAME>SDWLSRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWLSRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f616fa6862383b398f9a4c8671611b78">
              <SHORT-NAME>SDWRSFObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWRSFObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="050944f3a6c23d4280fb30cdb82946d2">
              <SHORT-NAME>SDWRSRObsRng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWRSRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0fc2d37eb9f939bc80db1c1466039914">
              <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFAudWrnng_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b972b6cd77833eb878d9aaa5d04f303">
              <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFSts_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f826facdd65b31bda0763dfe71ba2eea">
              <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8876120f4ab306ab7033da89d6601be">
              <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtIndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a1b965931e44309583211e1259a5453a">
              <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtIndResp_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ca2811f8ba03b21a71100cee0b46343">
              <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtInd_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c50309488ccd3f1e8d52458d4baa12f3">
              <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFWrnngMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3eef21a15a3b3904912f44cfc81b6315">
              <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFWrnngMdResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1291bf12cfe633a9882c1a8fa429a882">
              <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCLowPwrDwn_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="045ca635f32d33b9a8af258a74073354">
              <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCLvl_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da7d4026af643a50bae1eb62e617ec81">
              <SHORT-NAME>SOCMd_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCMd_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9482b8fd660639a6a7817da0c846a612">
              <SHORT-NAME>SSBTrigd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SSBTrigd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a383c86ae7b13d2781ff5aaf7248ede8">
              <SHORT-NAME>SWSCnfmSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSCnfmSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33374d39ac88335f8302b94608d2d92e">
              <SHORT-NAME>SWSCnfmSwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSCnfmSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a3805cf35ab2392f9f8481e4c6a79359">
              <SHORT-NAME>SWSLFnChngSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSLFnChngSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="601b77e4206137e6b1d360bdbaf7fb99">
              <SHORT-NAME>SWSPB1SwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB1SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da9b8fdb91e23797bbceea3e88d45fff">
              <SHORT-NAME>SWSPB2SwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB2SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8d14eb73631c3e1983d42ea9ae6afb7a">
              <SHORT-NAME>SWSPB3SwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB3SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4de55ba3e8883b99b698a931e52ff183">
              <SHORT-NAME>SWSPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b13c23f613e434728c83a9c7d2d98b5e">
              <SHORT-NAME>SWSSelDwnSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelDwnSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f12827013ce37349a543d69e4bd9e7b">
              <SHORT-NAME>SWSSelLSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelLSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ff146e5f5cb83fa493231ee1db7f0e2a">
              <SHORT-NAME>SWSSelLSwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelLSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f8e2efa495a3359da9e8ad1dfbfdb32e">
              <SHORT-NAME>SWSSelRSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelRSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc5e1b9c74b7310c8f8be4cabb786463">
              <SHORT-NAME>SWSSelRSwStuckL</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelRSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e13dc63b1eca38e68905df2838971426">
              <SHORT-NAME>SWSSelUpSwA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelUpSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb9313cca5e033119846d5116ea498e9">
              <SHORT-NAME>SatAz1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="556b6c68cd7e397881bd712b0a74ffcc">
              <SHORT-NAME>SatAz10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5de090dc73643f1cbe814903b560a07d">
              <SHORT-NAME>SatAz11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6cce479265713807a45dcc61aaa38334">
              <SHORT-NAME>SatAz12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57d79ef393df33849547727993413e29">
              <SHORT-NAME>SatAz13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="38f16c372cde38a3abb762528b2ea5d7">
              <SHORT-NAME>SatAz14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4938ce1e9acf3dcc8fa2e3b48712b551">
              <SHORT-NAME>SatAz15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d6c5cbeb7ef330e59085f52380fc081d">
              <SHORT-NAME>SatAz16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b79784cc5b4934e781910f7153132200">
              <SHORT-NAME>SatAz17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="329e48c34e543c69be27454d2d0ae8da">
              <SHORT-NAME>SatAz18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e7935555b8e336ab1406f9071e6f734">
              <SHORT-NAME>SatAz19</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c44694c77903bef9f98f0d3c7fe3306">
              <SHORT-NAME>SatAz2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16d5f6718c023b0b82b5bdac9ff629df">
              <SHORT-NAME>SatAz20</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e86f5169717f3654bd452ea2a4a17dbd">
              <SHORT-NAME>SatAz3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c40686e502863af197acdc3be3b2376b">
              <SHORT-NAME>SatAz4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f476c8f22d03340e9a338c85e6bcf54b">
              <SHORT-NAME>SatAz5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="26da5765a54f3f9b9f4bbb67e4992a1b">
              <SHORT-NAME>SatAz6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06e8f2cf22573b74ad72b43e898df12d">
              <SHORT-NAME>SatAz7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f9958c4c0123d71a124e3681a106467">
              <SHORT-NAME>SatAz8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5db91bf19ace3c90aaff4eddd45a469f">
              <SHORT-NAME>SatAz9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b11c91b809d37859bc9fc32d7c204f0">
              <SHORT-NAME>SatCNO1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c2c0cc791003c96aeccdd3bcddaf58c">
              <SHORT-NAME>SatCNO10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eda0f83315413020bc0e3b88a1e19adf">
              <SHORT-NAME>SatCNO11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="84566d0e2e9a35bfaa4f1fee8ac4c8d9">
              <SHORT-NAME>SatCNO12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd6aba28b3b1359391f7b479d40ab201">
              <SHORT-NAME>SatCNO13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de8c43388d3533c5ab854fadbd11dbec">
              <SHORT-NAME>SatCNO14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b1ba91768e13170b414edfaf1937a6c">
              <SHORT-NAME>SatCNO15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2536ed635cfd339ebe5af2e15aa12eaf">
              <SHORT-NAME>SatCNO16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1e5cfa7f290d3e0e8c12612a6af8f7fd">
              <SHORT-NAME>SatCNO17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="415571461d3733ed9bab080f514374cd">
              <SHORT-NAME>SatCNO18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd927d150222319cba95ca228e638dd7">
              <SHORT-NAME>SatCNO19</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4ff9e2bcdda3f6489ffde69b7b50756">
              <SHORT-NAME>SatCNO2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b0bfb3c90e03a75bcfb135d54f65091">
              <SHORT-NAME>SatCNO20</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="346fa9e1f8803c76ae67cbad9977a31e">
              <SHORT-NAME>SatCNO3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7074a008b420356b9b1fe602108ec796">
              <SHORT-NAME>SatCNO4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbf75c7460413f58bc4073f7fc68235c">
              <SHORT-NAME>SatCNO5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca7bc9e95f5f38578e8225ef2fd1ad83">
              <SHORT-NAME>SatCNO6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8cd698d647053f2daea46561d4b32bad">
              <SHORT-NAME>SatCNO7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf319b43a5b030c991568bd56012233c">
              <SHORT-NAME>SatCNO8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a33fab515b2935708c1cfad0ac0e7736">
              <SHORT-NAME>SatCNO9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="906c0c706e6d391cbf63119e2942cd8c">
              <SHORT-NAME>SatElv1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="069ee9440d3d37c699d46aa0160c857e">
              <SHORT-NAME>SatElv10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1785dfa9ccc32f9bd608c278f27326b">
              <SHORT-NAME>SatElv11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ae41689409138628a01e401096cb6fc">
              <SHORT-NAME>SatElv12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e13405b6c8835f794e5176724044e27">
              <SHORT-NAME>SatElv13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a790126092c934ef8bbab12dfede211d">
              <SHORT-NAME>SatElv14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29ed6528de9c3a71955df801aca35912">
              <SHORT-NAME>SatElv15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c4f1c31297f73de3b418a7ffde3e7d24">
              <SHORT-NAME>SatElv16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9cb9458cf2bb3af88b21b9f19bca3776">
              <SHORT-NAME>SatElv17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4efbb3d096ff3d4a96fd23a8065b811c">
              <SHORT-NAME>SatElv18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9ef973d9f4d3bebbbfeb3275547e55d">
              <SHORT-NAME>SatElv19</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16a1f6871cdc3253ab217f8a0b4aeec6">
              <SHORT-NAME>SatElv2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="778562af9b15317b933920343ba865c3">
              <SHORT-NAME>SatElv20</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="25ba957c7dc4330980b951536f5b05e9">
              <SHORT-NAME>SatElv3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd30f3f426ca3dfe897a2347be7d1364">
              <SHORT-NAME>SatElv4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b0d5040d439a3356be3a7c8e57f056c2">
              <SHORT-NAME>SatElv5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="740f009947cc3967b100165892491477">
              <SHORT-NAME>SatElv6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75d1551765e53df489468032deb91d42">
              <SHORT-NAME>SatElv7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="37138dc5da1b3878b1de759f6c3a44d7">
              <SHORT-NAME>SatElv8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a2ce520d7fab376aa981bc3f368a548a">
              <SHORT-NAME>SatElv9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65e76fa3844538979638c825b103c00e">
              <SHORT-NAME>SatID1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="269547241d8f38dda873c9afa009bccd">
              <SHORT-NAME>SatID10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce538a516c0530f2b2c96f19b7ba743e">
              <SHORT-NAME>SatID11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="229081a6d395392d8919049df8351b08">
              <SHORT-NAME>SatID12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ff8ff246dcb30e8ab6c78bd2848a0af">
              <SHORT-NAME>SatID13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="07b85431d16039159583d2b2fdf42ebf">
              <SHORT-NAME>SatID14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f6a56947e7c34e588708f7a9a57ea50">
              <SHORT-NAME>SatID15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b8571ef83e3a38789ea2138e7d8e5d4c">
              <SHORT-NAME>SatID16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c152083af4f233d29037b831c431b019">
              <SHORT-NAME>SatID17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="133e16abde87364aa18f2a2679f183c5">
              <SHORT-NAME>SatID18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e9e8cfb4924b3fd1b7e37b24b0ed6ea9">
              <SHORT-NAME>SatID19</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6352e3b851cf3b90b1cc2e2edf1b64c0">
              <SHORT-NAME>SatID2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9bfebacedb6a30249ec83138c203a5ef">
              <SHORT-NAME>SatID20</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f01489d61d4736578d854e13f5b676e5">
              <SHORT-NAME>SatID3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4986d0056b763ae1861b90984a91ebcb">
              <SHORT-NAME>SatID4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a4017c6b8be3c4cb068904999345739">
              <SHORT-NAME>SatID5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f0095833440b3799af80a0283cba993f">
              <SHORT-NAME>SatID6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21f4e9eee0fa37c2b992cea67321e12e">
              <SHORT-NAME>SatID7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33f72981aa793b1a84ff4bc04197622d">
              <SHORT-NAME>SatID8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="068453e88c8a31d2923b8e4f6bd4ab74">
              <SHORT-NAME>SatID9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="209252ca6b353dd3837d8fda3013d24e">
              <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNoInAttitudeRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e455e67140238bfa91271a59df5efdc">
              <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNoInPositionRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f6a07c4f9f03a6ebae53910ccc47cea">
              <SHORT-NAME>SatNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="112f307bd08b3b9f9e6287924dbcda7e">
              <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SeatOccptnNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d010b5da4cc355db9edf0f953a417d2">
              <SHORT-NAME>SecRowLOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowLOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="495c1fcbcc4736aa84b7a0b285d5562d">
              <SHORT-NAME>SecRowMOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowMOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5509fc71409c36b4b6652f72910105f0">
              <SHORT-NAME>SecRowROccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowROccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ece15296ffb33a2b33b58edb58ff480">
              <SHORT-NAME>SecuKeyVldSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecuKeyVldSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb0e289a049b350e90de4250eb2a3322">
              <SHORT-NAME>SecySSBA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecySSBA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a688974e47636688709009e8ef9243f">
              <SHORT-NAME>SecySSBAV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecySSBAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="420418f0d8a730eca57e292663945a85">
              <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ShftSeqStat_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a3d72e20f753d01beeec90b7b43ef66">
              <SHORT-NAME>ShwrmComprEnbReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ShwrmComprEnbReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06ddfc3271113db994e3ec5b7fd8b6b7">
              <SHORT-NAME>SideLghtOnReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SideLghtOnReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="53b17142edfa312ebed0613a424e8b90">
              <SHORT-NAME>SideLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SideLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96a8fe68be2133ad9065f134e31b4145">
              <SHORT-NAME>SmrtKey1BtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey1BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8ad44fae3b573d29af232cd7d01cf470">
              <SHORT-NAME>SmrtKey1LoctnResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey1LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20b7a87f318932ebb2c851d496447b3d">
              <SHORT-NAME>SmrtKey2BtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey2BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="029c909237a63dcba0c12c238395f87d">
              <SHORT-NAME>SmrtKey2LoctnResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey2LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b70a6e7f589306cb01f6b8a9b77e078">
              <SHORT-NAME>SmrtKey3BtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey3BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c378d0446393205bc447d2f476c7053">
              <SHORT-NAME>SmrtKey3LoctnResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey3LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8047b2c34f69370d99dd388b191947e6">
              <SHORT-NAME>SmrtKey4BtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey4BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6de90c80c2334dcaa67085dfaf6e2b1">
              <SHORT-NAME>SmrtKey4LoctnResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey4LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="208ccd7cca07317c892e9c907dca1d07">
              <SHORT-NAME>SmrtKeyLoctnFlrRsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKeyLoctnFlrRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="111008e3fc22375b9f8650321ca13077">
              <SHORT-NAME>SmrtKeyLoctnProc</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKeyLoctnProc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee6fc60a44113f8f8b68788e2f82b55e">
              <SHORT-NAME>SmtKeyAuthnMnModRunSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmtKeyAuthnMnModRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f0f0090796ad3819b0863eef2f8b2ea1">
              <SHORT-NAME>SmtKeyAuthnSubModRunSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmtKeyAuthnSubModRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9648be78d6ce345e87f6ed5e02661c4b">
              <SHORT-NAME>SoftSpSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SoftSpSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b7711ff3e049399bb2d29fca40d18b51">
              <SHORT-NAME>SolarStrngLSide</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngLSide</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="66c62497470238e0aacd5cf8cdb2442d">
              <SHORT-NAME>SolarStrngLSideV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngLSideV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0bb0470e004e35b4bb72b2c3c1fc5c28">
              <SHORT-NAME>SolarStrngRSide</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngRSide</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b86659a1edac3853a81e955c41d53a4c">
              <SHORT-NAME>SolarStrngRSideV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngRSideV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33e250b0f8fd3c3f98fb1bc6fc97e376">
              <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdAstCndStsCamr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ec325dd3b2d3d798ca6a91545f8f686">
              <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdAstSysTrgtSpd_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f44af5fccc963aab9f9c7eafc55416b9">
              <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLimitManualSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="60238452d540306592cb0ed258acd2b8">
              <SHORT-NAME>SpdLmtMdFICM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b9d0e2a5fc703acdb18fe8666683aefd">
              <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="143cf79a7fef3af081ee99a5a47f2330">
              <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82e3e26225ea3669956df6f4eaca8ceb">
              <SHORT-NAME>SpdLmtNav</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b06628ee24353f34ae33565faf72ffa3">
              <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetNumReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16c94a10eb3835aeb3791d8658ee4695">
              <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetNumResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ad5f1e1f86f317eaae0b6ae806a2ef9">
              <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetPercReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a96378f72c343a2d8cf7e11a42a7d9e0">
              <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetPercResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="80c962252c6e3fe2b0c7bbc9baacd16d">
              <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1992ac7bc6683b7bb9b8cd29e036dea7">
              <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a1cce46529631d382e9432e417da9a6">
              <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtPathRngNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="960ed199a1d23e1ab65bf97c53c08ef4">
              <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpedRegulaModSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="993257141c8b3546b08c10435542b677">
              <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpedRegulaModSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="697b033a2398397e9ba65a9baa784e2f">
              <SHORT-NAME>SpfngDet_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpfngDet_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f6647ad513e3806b03da6b31010acc8">
              <SHORT-NAME>SprSportSubItemReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SprSportSubItemReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="074d0437730c375ca8ebff05af850967">
              <SHORT-NAME>SprSportSubItemReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SprSportSubItemReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a36508928cf0300f84901207598f29bf">
              <SHORT-NAME>SrfOpenSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SrfOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="baed670ce7273916a08ca4b62bc81df6">
              <SHORT-NAME>StrgCustSetngDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgCustSetngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01cd41a9b3f532be92cedcd0928c8813">
              <SHORT-NAME>StrgWhlAng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6b09f05391023bf1b2c249626f523f30">
              <SHORT-NAME>StrgWhlAngGrd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngGrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a644379f2b433cf58e156393963345b6">
              <SHORT-NAME>StrgWhlAngSnsrCalSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrCalSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb9ded0100fb31f3ba41029650b60a0c">
              <SHORT-NAME>StrgWhlAngSnsrFlt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="04b0e6742e993eaab8ad0287f6c4a08c">
              <SHORT-NAME>StrgWhlAngSnsrInid</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrInid</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65d44820669838e3982b9189d7a080a7">
              <SHORT-NAME>StrgWhlAngSnsrMultCapb</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrMultCapb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf0337e3447f370d979853fcdbd9dc65">
              <SHORT-NAME>StrgWhlAngV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="527be3d9fffd3d97b1b666a22384364c">
              <SHORT-NAME>StrgWhlTipcSwDataIntgty</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlTipcSwDataIntgty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9bf23666bdfd3addb8f5dcd183aa7514">
              <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrtTypAvail_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e14ed744512c373a848b63b8be354aaa">
              <SHORT-NAME>SusDmpngCtrlCustSetngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SusDmpngCtrlCustSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e28215ace0e399bacf091fd9c07c198">
              <SHORT-NAME>SvGroup</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SvGroup</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="02d84a9e0bae39428a43eb5a0e4165f2">
              <SHORT-NAME>SwStaE2EErr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SwStaE2EErr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ffa91bde723a3a14848c60c78418c95c">
              <SHORT-NAME>SyncMsgCheckSum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgCheckSum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a52b158167a3bf290cca302f374f3fd">
              <SHORT-NAME>SyncMsgOVS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgOVS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4874f8a2424328db0a540224e58613a">
              <SHORT-NAME>SyncMsgSGW</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgSGW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61417720cf1f3959bdac542c52102f9b">
              <SHORT-NAME>SyncMsgSequenceCounter</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgSequenceCounter</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79daa16732f2305aa2500a01e5bff712">
              <SHORT-NAME>SyncMsgTime</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgTime</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="535f456ce6b734d8bfbcbcdd8b1ecf7e">
              <SHORT-NAME>SyncMsgTimeDomain</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgTimeDomain</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="56d53110daad3a39963f915fdbefeae3">
              <SHORT-NAME>SyncMsgType</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2dc4d0c830c3eefb9f766e3877bbbfc">
              <SHORT-NAME>SyncMsgreserved</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgreserved</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="30c68771baf933399161ac742ba7889e">
              <SHORT-NAME>SysOpnlMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysOpnlMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b91d7b1eb158319bba2ee1ecead3f8de">
              <SHORT-NAME>SysPwrMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="799f8ad1a2413b9fb5033c6be4bf378d">
              <SHORT-NAME>SysPwrMdCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMdCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="849870cc5ae63467b07e8c5a926b5161">
              <SHORT-NAME>SysPwrMdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa532023dde7367c83c19c45094bc684">
              <SHORT-NAME>SysVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d108337c1a735598b7aae6108aae94c">
              <SHORT-NAME>SysVolMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da9126ccfb913eba97625ad4f498a540">
              <SHORT-NAME>SysVolMdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="71f57b76596a3c8ca1f7d6f5a139a733">
              <SHORT-NAME>SysVolV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6b9d14796edd36eb9fd7c597c9189e7e">
              <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TASSAMTqSplt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a9c8d6aaf6fd3c1c85e22304bd1758af">
              <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TASTMTqSplt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a06c986b3326372dad6e5d7205e5cd39">
              <SHORT-NAME>TCM_020ms_PDU18_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="851de6d0d9a834ee802b593b4c1b5e81">
              <SHORT-NAME>TCM_020ms_PDU18_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cce6d7ec211f38b58c5988899a444fc5">
              <SHORT-NAME>TCM_020ms_PDU18_Reserve01</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20d1930fca4d3ee5a457cb8aba31d7a7">
              <SHORT-NAME>TCM_020ms_PDU18_Reserve02</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve02</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31f32df599ef32a499313a443fd805b2">
              <SHORT-NAME>TCM_020ms_PDU18_Reserve03</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve03</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed14b48245c53245a2f0a7ba71a56350">
              <SHORT-NAME>TCM_025ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0abac8415cc135dbb759cf6d2c09d4f9">
              <SHORT-NAME>TCM_025ms_Group02_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1af0eda8a82c3f2794efe1491ccf4b77">
              <SHORT-NAME>TCM_025ms_Group02_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd3a741e4e0038d4b82664929b0fd51e">
              <SHORT-NAME>TCM_025ms_PDU02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e1b2dd8505f33a0b3cdfa956f38c424">
              <SHORT-NAME>TCM_025ms_PDU02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="783a7364ed66336c8305b163604f8bf3">
              <SHORT-NAME>TCM_025ms_PDU05_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="44939379e4da390b964f0e68105dd28d">
              <SHORT-NAME>TCM_025ms_PDU05_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96cc9502748833f2a86143ab3fa15d6e">
              <SHORT-NAME>TCM_025ms_PDU05_Reserve01</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="542f37966f3e3a9f819f74bac4ecab9f">
              <SHORT-NAME>TCM_025ms_PDU20_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbd7af3c3f3d329cb4dfa154d4e01a28">
              <SHORT-NAME>TCM_025ms_PDU20_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b582e92362f3ab2802cb23ef81a89e5">
              <SHORT-NAME>TCM_025ms_PDU20_Reserve01</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="709492723fc438f595344b0c5187c74d">
              <SHORT-NAME>TCM_025ms_PDU20_Reserve02</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve02</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f6ebfb1e1b89340cbc958303996227ab">
              <SHORT-NAME>TCM_025ms_PDU20_Reserve03</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve03</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5b84ea99346636aaaef92b7c34ed8953">
              <SHORT-NAME>TCM_025ms_PDU20_Reserve04</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve04</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d71fcece38e83e0bb2c2ae72eff0808e">
              <SHORT-NAME>TCSA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="17ae4d0ef44133149427955d6063bdcf">
              <SHORT-NAME>TCSDrvrItnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSDrvrItnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b36ddedb50636a687cb744001b300c7">
              <SHORT-NAME>TCSEnbd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSEnbd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0955132a23ad3de29012bc73913f1605">
              <SHORT-NAME>TCSOpngMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSOpngMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="170cc5abebd235529575312b91981512">
              <SHORT-NAME>TCSOpngSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSOpngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb18b8a793fd308c98bc2a5c960844f8">
              <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUIntvSAMTq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fb7bf4066403320083460238fef5594f">
              <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUIntvTMTq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8699e243c716357d996177aeb73c01b0">
              <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUOpSt_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="381e702b26e03ea7adec57969c35d6c8">
              <SHORT-NAME>TC_ExtdAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TC_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc1e248e54c23b059a3d5739cfca8b21">
              <SHORT-NAME>TC_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TC_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c6230f415fc39709695e8bd22af46c5">
              <SHORT-NAME>TDMAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2d76a1e6b417321b85ede04308e1a953">
              <SHORT-NAME>TDM_200ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2bcab98d0c4e371598113d402788d0b1">
              <SHORT-NAME>TDM_200ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cfe47179e4e53d1185fa7c69db27cbaf">
              <SHORT-NAME>TDM_200ms_Group01_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d86af32f5e6d3ac89a730371ac11dd0f">
              <SHORT-NAME>TDM_200ms_Group01_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bac63b7193e63cc0a13f4fa43f95e976">
              <SHORT-NAME>TDM_200ms_Group01_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a75da116802d3c0bb2cdddd93ceac639">
              <SHORT-NAME>TDM_200ms_Group01_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd26dabfbe0e3f6c9b29a7a5bcd2ce6e">
              <SHORT-NAME>TDM_200ms_Group01_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94edaf870fe53f81a2fe8c206f4f1625">
              <SHORT-NAME>TDM_200ms_Group01_Reserved27</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved27</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33112c8aa62c3975aa8d80cd9e042d61">
              <SHORT-NAME>TDM_200ms_Group01_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fafe8fe562473bc98f1021d4349794e9">
              <SHORT-NAME>TDM_200ms_Group01_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="156be0bdb57b363f893c7944003ee3ee">
              <SHORT-NAME>TDM_200ms_Group01_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d04ea4026d453212839370cc0862fd3e">
              <SHORT-NAME>TDM_200ms_Group01_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f7bf441227f834de9e0ff9ec80ba16df">
              <SHORT-NAME>TDM_200ms_Group01_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06e2399a5f7b3cdba06170de74fa4bc2">
              <SHORT-NAME>TDM_200ms_Group01_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c930f0da3a733f59ada297042584d0a2">
              <SHORT-NAME>TDM_200ms_Group01_Reserved87</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1b3a040922e137679efa79115e641cdc">
              <SHORT-NAME>TDM_200ms_Group01_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a2aedd4784d368fb0219782d6098bfc">
              <SHORT-NAME>TDM_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82851a81d8e237da83562c31d95062a8">
              <SHORT-NAME>TDM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b45ef922d2c3e00acb324ffb184fe88">
              <SHORT-NAME>TDM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="877dd1b8655539a6a1eabbf3198a0aaf">
              <SHORT-NAME>TDM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63584521da1a36b3939ed4ece2d783a7">
              <SHORT-NAME>TDM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="230586b46b9339818feab23b06cf0977">
              <SHORT-NAME>TDM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08fd2b927a433890b1175d041f4a646f">
              <SHORT-NAME>TDM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93d3ea2998963ae58357afd5b6009348">
              <SHORT-NAME>TDM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e31cd85822243282aedd571e4d760f48">
              <SHORT-NAME>TDM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57d3262c57fb3031a8423967e0ac08fa">
              <SHORT-NAME>TDM_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="03cb31aeafbd3cfb89f8c771eb720321">
              <SHORT-NAME>TDM_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee89aa9fe89433c8a860a8deeab6fecf">
              <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICAMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8622161715ba3e8fa8a7726b8a54528b">
              <SHORT-NAME>TJAICASysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICASysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9326bc424b5739d4a89cb3247f0a195d">
              <SHORT-NAME>TJAICASysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICASysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a56e56cd3b0c37d7922975d2870006db">
              <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMdSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f1ad7bd14763905af20d25a6a86f328">
              <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c010c1734d83599b76f1ed3b1b63621">
              <SHORT-NAME>TLRMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ca912da2c74313aae0123b11c6e381b">
              <SHORT-NAME>TLRSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="721020e51d8a3416998c6f0c42aa4831">
              <SHORT-NAME>TLRWarning</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRWarning</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b27abb3b75838dc9f8cf7a135710fc2">
              <SHORT-NAME>TPMSAutoLoctnCm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSAutoLoctnCm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3dcc0735b3e2347897bb4ecfb3bb12f1">
              <SHORT-NAME>TPMSAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f445aa60cf273d18991ba29cce23dc86">
              <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSBtmNosRSSI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13e4b6ca22ce3e67993b4760e27a37b9">
              <SHORT-NAME>TPMSF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="165475a91ad83f45a769b540466455d0">
              <SHORT-NAME>TPMSIdficnLrnCm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSIdficnLrnCm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="70f2a82640333c9b8ae325fc8ee9bcc9">
              <SHORT-NAME>TPMSPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="076f11ae471b39fe9bb4e2344c2320ca">
              <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2eede093cf913447b598a319b37d578b">
              <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrIDLoctn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="485b7a51c1a93e2cb3e7511fbfa468de">
              <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRSSI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4df4e08f976234a1a5f15b3c3c3cbb77">
              <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRdoFrqcCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f91f590457e307b9cef8cb64b8e62d9">
              <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRdoFrqcCtrLoctn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e205833b3c6343890d36718ce824afa">
              <SHORT-NAME>TPMSTirePrsLowIO</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSTirePrsLowIO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8360d19761dc33cfb62b6d910bfe736d">
              <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSWntrMdA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db328efba4093c50b3997613a9732a79">
              <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TQRTMTqReq_N</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bffeb57c4c2c39abb86e39bfb96aa1eb">
              <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TRCEMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c39281a8945358c885067bcc245f49c">
              <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TRCTqDmdSTC_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82e76b7e2994318280db2bf20869d9d1">
              <SHORT-NAME>TSRSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="148259f8c131341183b93327429ee3c5">
              <SHORT-NAME>TSRSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c78c9bdbc6743dc7b77af1cee38780e1">
              <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSwReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="579b3b20a6e53e5ab222ea2b5a0e48f4">
              <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRTrgtBanSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc68534f7ed43b599e869d5ae66cd58c">
              <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRTrgtWarnSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e34a35b96bd63feaa30d09da15f03eb6">
              <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TZXEMMaxTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4880504a4e1e38abb094d18d3d2e3d5f">
              <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TZXEMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1e332746be4a3c73a047290d24174ac2">
              <SHORT-NAME>TakeKeyOutRmndr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TakeKeyOutRmndr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="892f259135463bc8a0f6ce1a0a51f105">
              <SHORT-NAME>TakeKeyOutRmndrPersSetReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TakeKeyOutRmndrPersSetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="99f76b32b972347ca203a9445e53a0c1">
              <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TemSnsrHdwrFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2be7be05b323b7688bfbfb784a733e5">
              <SHORT-NAME>TgtParkingChosed</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TgtParkingChosed</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b61db83fe5631468c2ea85623d68a1c">
              <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TgtParkingFavorite</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9a959fa0bfe36afb9962013b726fe7c">
              <SHORT-NAME>TiltSnsrSetngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TiltSnsrSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39daf60d20a83bd2aeedfe85eb41c756">
              <SHORT-NAME>TimeDspFmt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TimeDspFmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aa4c721720ca331c997d16b0020fb0fb">
              <SHORT-NAME>TireBlowoutPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TireBlowoutPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e39de188ca723b49a9520f18ba32bf77">
              <SHORT-NAME>TireBlowoutStabCtrlSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TireBlowoutStabCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="317e01f1680a3ef5a00550eada966209">
              <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ToEPSMsgChlg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="998590cbb7a832979a6c8a9c36840bf6">
              <SHORT-NAME>TotActuWhlToq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TotActuWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2c60fa3872a35fe8347b7db6b8234ea">
              <SHORT-NAME>TotActuWhlToqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TotActuWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e43e66d8ab23c25a700dad0c482f075">
              <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TqCtrlStat_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c09cda716903073b5ab4db9f5d24065">
              <SHORT-NAME>TrACCToqReqResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrACCToqReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fdd5a8973d1d30e19bdf8600511f463e">
              <SHORT-NAME>TrAPACanclReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrAPACanclReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f83c450f0a0a3b98bd0cc7b0428800cb">
              <SHORT-NAME>TrClThrmlProtnNotfn_ECM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrClThrmlProtnNotfn_ECM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a7dbf44fe0a3a4f99d76f50362ea8ee">
              <SHORT-NAME>TrCrkshftToqLd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrkshftToqLd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d855639b3d834dfa9c4dc99538a8869">
              <SHORT-NAME>TrCrkshftToqLdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrkshftToqLdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9317415b2fc73e9b91d93467cf8db5a9">
              <SHORT-NAME>TrCrpMdA_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrpMdA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b0ffc43bc1f134f7aad82e52864a206e">
              <SHORT-NAME>TrCustSetngDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCustSetngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="25ac77aaa70132bc896dad946fc5449a">
              <SHORT-NAME>TrEPBAppReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEPBAppReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d53f87bb90e3ba1b3a537237f570952">
              <SHORT-NAME>TrEnASSOvrd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEnASSOvrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05444260d07d3de988f013408efa27ec">
              <SHORT-NAME>TrEngdSta</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="120bb5ea11f534acad9c61e074e62ea6">
              <SHORT-NAME>TrEngdStaV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdStaV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b2e7188931c37378f2a026f0d2c6ef4">
              <SHORT-NAME>TrEngdStaV_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdStaV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0675fff5d88b3377971f16fcc118f9fb">
              <SHORT-NAME>TrEngdSta_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdSta_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82d934a3f1f633d494bd29d40bbae2db">
              <SHORT-NAME>TrEstdGear</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b969934cc9b13af58d5331c9a604d398">
              <SHORT-NAME>TrEstdGearV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGearV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbdea41b546f33819354800721ae5129">
              <SHORT-NAME>TrEstdGearV_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGearV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6eacf3c53762386888a3eeaf764e3c29">
              <SHORT-NAME>TrEstdGear_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGear_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="55b53efc7f2131578499acd264c86550">
              <SHORT-NAME>TrGear</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a236589e867377eb480ffb8d65662ab">
              <SHORT-NAME>TrGearV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrGearV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbf82dca2c4e3b2fa47857ebbd64a6f3">
              <SHORT-NAME>TrImmdCrkshftToqReqVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrImmdCrkshftToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5262208fb4e43a92906bf67d95eec95c">
              <SHORT-NAME>TrImmdCrkshftToqRespTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrImmdCrkshftToqRespTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81ad14bbbb40360e83225e39738e6a4b">
              <SHORT-NAME>TrInptClStsV_ICE</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrInptClStsV_ICE</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6489d968b903242b50da1193bbac96f">
              <SHORT-NAME>TrInptClSts_ICE</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrInptClSts_ICE</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f5f5c70c87438d8ad896c63e36765e6">
              <SHORT-NAME>TrIntnlSwPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrIntnlSwPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d8eb40073aac30cba8b505e6abdc74d6">
              <SHORT-NAME>TrIntnlSwPosV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrIntnlSwPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a6e27c2e65833c7b422419ed7ffb739">
              <SHORT-NAME>TrMinVolReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrMinVolReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d32abe6b210b378c8746568fd662628f">
              <SHORT-NAME>TrPfShftPtrnSw1A</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw1A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62b9a915f81d3d07b65c6eb4bfd3ff75">
              <SHORT-NAME>TrPfShftPtrnSw2A</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw2A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bb1682e9a7e3be7a594a226afe4cde6">
              <SHORT-NAME>TrPfShftPtrnSw3A</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw3A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4876714f39c3a0ea549a47b6d088912">
              <SHORT-NAME>TrPfShftPtrnSw4A</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw4A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8c644940ce0c3e99ad6fdc671e245169">
              <SHORT-NAME>TrPrdtdCrkshftToqIntrvnTyp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrdtdCrkshftToqIntrvnTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7834d7ab0f9439199fa9a10953b4d1b0">
              <SHORT-NAME>TrPrdtdCrkshftToqReqV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrdtdCrkshftToqReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f3e84cc52a313fbc9aac600a9340be27">
              <SHORT-NAME>TrPrkPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrkPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b13eaa774d4f38ccb1f3e9dd488f6400">
              <SHORT-NAME>TrPrkSysF</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrkSysF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f2b493b10e93b75b534bec80d4ad092">
              <SHORT-NAME>TrRngInhSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrRngInhSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8e2da13d58a43df7bee92f6bed6412d6">
              <SHORT-NAME>TrShftLvrPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a06641265b673346a770bb519c932e8e">
              <SHORT-NAME>TrShftLvrPosV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac686f7b614c32ee9c89c6b043f711f0">
              <SHORT-NAME>TrShftLvrPosV_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPosV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b850dc668c443a0daf588e43d9c2160c">
              <SHORT-NAME>TrShftLvrPos_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPos_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b2e95b34465b3c22ad06e66947c7e5ca">
              <SHORT-NAME>TrShftPtrnASts_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftPtrnASts_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bd4e827e03b33fcbf2b5fdbc031c42d">
              <SHORT-NAME>TrTapUpTapDwnMdSts_TCM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrTapUpTapDwnMdSts_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="11881342052d37f593fe559d7be38ee9">
              <SHORT-NAME>TrTrgtShftLvrPos</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrTrgtShftLvrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ef0030265223c94978078969f612ea7">
              <SHORT-NAME>TrWrnngDsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrWrnngDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f06baddf37835c29cc268797ea0e1d0">
              <SHORT-NAME>TrdRowLOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowLOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f40aede483373d7f9eafaf0f1999fe09">
              <SHORT-NAME>TrdRowMOccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowMOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e51441128a233f3a613580fdd874239">
              <SHORT-NAME>TrdRowROccupntSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowROccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d22fe28efa6c3009b31d9a366a049842">
              <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnKeyBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7e117c029b235dc858442f89b69142a">
              <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyFindCarSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1697b758f4633ea1b7c548db63df2771">
              <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyLckSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="309fad079c2033d5932fc52940bbde82">
              <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyLdspcSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d767f0a30f3348ca4af3261a96939f3">
              <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyUnlckSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c4dc7a9681d3e69a1c393a342135684">
              <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfGreenLghtActn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c529fff226423d03b55d1dd019c413c0">
              <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcForbidDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4392bbb275e43159acfdb47437f61684">
              <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcInfoSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0bc2ea8e7db634f8afe0f2e98c575879">
              <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcJamRngNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="abe105ad040e3559b2eeb6baf27b3c24">
              <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtFuctionSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="62d505212fe9351788b32025ede4f226">
              <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtFuctionSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0fefa8c9797b3d3d962f52b57703d526">
              <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcLghtStSp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f749cfb89bec30eca489c9ca3ff749e0">
              <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdForbidDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f89c5ad29b0a32008b30532b93fb6f16">
              <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdForbidSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7678dc3a54c3e37994200ca9b09de86">
              <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdInfoSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="231f944fb6653f6abaa0d217a72390dd">
              <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdInfoSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8f2152e13793b5182f27f4d63f63237">
              <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdWrnngSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5fded07956743312b5991fc827ae003c">
              <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcMrgdWrnngSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20e6fbd0caea3b5e8880addc2949e8ca">
              <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtCndSpdReqCamr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd46f41b70e83744aef7c55de297ec53">
              <SHORT-NAME>TrgtSOCReqAI</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqAI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea5eefbc93703cd4b4f70accad50a405">
              <SHORT-NAME>TrgtSOCReqAIV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqAIV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c994269d27373691800f35ca5a315d37">
              <SHORT-NAME>TrgtSOCReqFICM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9825d54d6ad3d9cad12f0e8461928ca">
              <SHORT-NAME>TrgtSOCReqFICMV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCReqFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7d1c40172c83481b0b1f1a2ae3aae3e">
              <SHORT-NAME>TrgtSOCUpdtReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSOCUpdtReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a3332776a2c399c8c30093234619956">
              <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrgtSpdSrcSts_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f1050727d8103b6b8a069ed9cdeafc6c">
              <SHORT-NAME>TripCnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TripCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2d5d693a9f0363fad06fec58e0903d9">
              <SHORT-NAME>TripCntResetReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TripCntResetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="627fcbfbfec63521b862bcf8186dcd40">
              <SHORT-NAME>TrlrCnctSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrlrCnctSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e49f25bbfdb351795a497af8271ee61">
              <SHORT-NAME>TrlrMdSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrlrMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5505511abf3b3968a4313853583c0fa1">
              <SHORT-NAME>USBHubPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/USBHubPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="18138e0a224e3a71af997bde20d486cb">
              <SHORT-NAME>UsgMd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/UsgMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc81a8b014ad3253857981d981b9193d">
              <SHORT-NAME>UsgMdV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/UsgMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="743538253bfb3f0086aad0a7ca923f2b">
              <SHORT-NAME>VCUAPAFltRsn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUAPAFltRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e0d0b3cbf58f3572b0c528fa973f13d8">
              <SHORT-NAME>VCUAPAUnderCtrlA</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUAPAUnderCtrlA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6e6fb711a3c0346ba4b73864ca22bcde">
              <SHORT-NAME>VCUCtrlS2Req</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCUCtrlS2Req</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d6687239ccbc39b29a4ac9f61b6617cc">
              <SHORT-NAME>VCU_ISAOvSpdOvRd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/VCU_ISAOvSpdOvRd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="06eca82172953f96be4f8c86037723cd">
              <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
