                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a657869da9d2372ca7e03788f8f4051d">
                      <SHORT-NAME>ICBVC_250ms_PDU52_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="c385d465358d3d5599204b79f42e202f">
                      <SHORT-NAME>ICBVC_50ms_Group11_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c482b95af5bf381da2d25e98b7a2c182">
                      <SHORT-NAME>ICBVC_50ms_Group11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5f10dc4cced3b5f99e232494a19b899">
                      <SHORT-NAME>ICBVC_50ms_Group11_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ed114644d0932d49d2cae2eba701d0f">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5e4a2e7037213e9c8f3799827d4d0b2b">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fd6777560f73f15b03367b41eb91ecd">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6b13d886fd23c42a48c10d65a8c0f25">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0dc37f403848362a94533971c6b0b7bf">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f59d4308e2023b0cac3e9bd24572158e">
                      <SHORT-NAME>ICBVC_50ms_Group11_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4950988061e3330280f3f9f040984792">
                      <SHORT-NAME>ICBVC_50ms_Group13_CRC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="01fb87a7edf93e3983d2740f6a346315">
                      <SHORT-NAME>ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c86fe552e5c3653ba0b96e6d1f2ad6f">
                      <SHORT-NAME>ICBVC_50ms_Group13_RC_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="156906b65d173997bf60006e11e8b475">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="05785c3b8f7d33d895e404c7d5e00d90">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a83c2bd39bd370e8988bbdc425853ba">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="14c6ec4806703f3f8ebbbedcb9f40354">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e33fe4156cc3ad4a110fd79cd28bab1">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d87373616d63562a97c60a2480f2ee2">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a72c76e03ff351eb631294322caffe6">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9984d3cca8583400b17bab9a672bd273">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a6b82bbff753b78a06bcc43556eb33f">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea5a420d53f73bfc96a0c058f3cf57e3">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8525638e85303fb59f1864e8dc5905ab">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ce09a14e4eb3e908c268de5e76159cb">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d086af786253033b0df0d2ebd3b2f5e">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c818710486a13ecf802e94cb9e94a113">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12a1b359e872384fa951a0aecbcf491b">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="60da6e47f8db3ca2a25cf999484aaed9">
                      <SHORT-NAME>ICBVC_50ms_Group13_Reserved9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e9af0297181a39a6868eeb5592fe48f6">
                      <SHORT-NAME>ICBVC_50ms_Group158_CRC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8ce37cfbd8f63a28b2b7993ed5487a9d">
                      <SHORT-NAME>ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bfc654ee067337848b38b6a66d85809d">
                      <SHORT-NAME>ICBVC_50ms_Group158_RC_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2972c37aefc136c5b8171de78ddc2bef">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a80eb9715b83f3f94449e11ef619d13">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="715109c6c626382a9a8f6c3fe5e209d9">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dfdb285b7ea33237af8d7d6f3dd09f19">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd3922c2482435ea9102c0613d933090">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e09eded38ba43cf59ff632e51834756d">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9119cffcbbd138dcb1c76e9720bb3f6f">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ff0666e2fd83f9e8725a718eb60d435">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f6b16b85cd5a3880ade49a2571fee06a">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c8caf62855a3a1daea4118c163dd28a">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4be0c9a18a330f886dc660fd6f8a289">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3b4ebdf3e5763095af710605bfddc8ff">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="364fa2efe3213403b35c1be1c9f89bcf">
                      <SHORT-NAME>ICBVC_50ms_Group158_Reserved9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="14a0634096c33cd5b312169bba7a2878">
                      <SHORT-NAME>ICBVC_50ms_PDU11_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="547d1fa14af23659941608901fb0ec2d">
                      <SHORT-NAME>ICBVC_50ms_PDU13_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="09b7a46d16b13976a0f149018aeb8352">
                      <SHORT-NAME>ICBVC_50ms_PDU158_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b52873fbd0a53663932f67b312d19f95">
                      <SHORT-NAME>ICBVC_50ms_PDU55_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="bdd33944541b3428862e7361064b9bd2">
                      <SHORT-NAME>ICBVC_BKPCANFD_1000ms_FrP50_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="85067283dadd3b4cbed918eea4cc15c3">
                      <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5d26358f22f53efd96bd858b1b8f108e">
                      <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP17_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6deb65adf4313830b026091354eef287">
                      <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP25_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4632adeaa2163ccaa8d0d9dc65cb76e4">
                      <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP31_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="bef6ae6f69c63de09c242b285d526b84">
                      <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP35_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d17b0ca4c3e138e7a216e13c582ba101">
                      <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP11_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1367192139b3368698705c4b6aa45068">
                      <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6e63a6f2f4693353abebaebe80abc22a">
                      <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP55_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="513febe2d932336487315c40c755d99e">
                      <SHORT-NAME>ICBVC_BKPCANFD_Event_FrS138_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="8454c8dcca623093bf536f32bbda85a1">
                      <SHORT-NAME>ICBVC_FOTASts_100ms_FrP47_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="7f7d4511ea7f3fa99362dcb034c3e8d3">
                      <SHORT-NAME>ICBVC_INFOCANFD_250ms_FrP52_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1933ad0825b33d42a4950a3b169f452e">
                      <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP27_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="bc7a17e79e803b21ba11799a108e3790">
                      <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP48_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f1f730db42aa3715b5e0a71a15fbbbef">
                      <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP80_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="308a6da410ad369e86fab4395af7afbe">
                      <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP50_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="3e798e4fb7563fb68610e6241bb0be47">
                      <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP79_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="ba672d2dc4f83dcab40e025759502e69">
                      <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP00_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="799fb2b5250230bb86dbb786bc19bd8e">
                      <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="6707f18304693ba09989d08bc79448e0">
                      <SHORT-NAME>ICBVC_SecOCComKeyReq_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="3d667fbd912e3facb67bdf2b20b63f8a">
                      <SHORT-NAME>ICBVC_SecOC_ComKeyReq_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a001a21bf4923ce5a136b9b431f65bba">
                      <SHORT-NAME>ICBVC_SecOC_SyncMsg_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="343f91090c7534a7bf996de6d7d2811b">
                      <SHORT-NAME>ICBVC_SecOC_SyncMsg_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="36bfc093fa993ca1bb2d0fb1c7d67d96">
                      <SHORT-NAME>ICBVC_Sporadic_PDU138_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="4001d2f558b23b05bea6762fbb7855a8">
                      <SHORT-NAME>ICB_100ms_PDU146_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="2b727320c14e3d24a45a40826b0a636e">
                      <SHORT-NAME>ICB_100ms_PDU147_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d1978ade00283180934d1ca68eb17294">
                      <SHORT-NAME>ICB_100ms_PDU159_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ac229608b89635ea89a3be363ff6eedc">
                      <SHORT-NAME>ICB_100ms_PDU221_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="058ddd630cbd3eb6a7f8a125a73a8ec4">
                      <SHORT-NAME>ICB_100ms_PDU82_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ac529a16d8bf34239e1ab5e175edfc3c">
                      <SHORT-NAME>ICB_500ms_PDU229_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="424fafaa28ed3c7eb6ac845b8e37771b">
                      <SHORT-NAME>ICB_BKBCANFD_100ms_FrP146_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="ba40c992d5de30e6830d69419cee4f77">
                      <SHORT-NAME>ICB_BKBCANFD_100ms_FrP147_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="8ae90fd4584c3ec3b7291f2fce7f2bd5">
                      <SHORT-NAME>ICB_BKBCANFD_100ms_FrP221_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="310e561d8fb63b49b0c13af8746ea0a6">
                      <SHORT-NAME>ICB_BKPCANFD_100ms_FrP159_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0d1e10b83c0b32ccb2abe64f8bba0b51">
                      <SHORT-NAME>ICB_BKPCANFD_100ms_FrP82_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f508ddbfdca931bbb4abda7b83e9ad3b">
                      <SHORT-NAME>ICB_BKPCANFD_500ms_FrP229_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0269af7c1a5b3e329a3ac3cc266d8a2b">
                      <SHORT-NAME>ICB_BKPCANFD_50ms_FrP158_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1b8aee305e083bd095ff0bdb53f49d3b">
                      <SHORT-NAME>ICB_CONNCANFD_Event_FrS67_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="5e8dc9e7f10739e5843305c8b47a6159">
                      <SHORT-NAME>ICB_Sporadic_PDU67_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1a72d4a3b3a53eba807b38af38807030">
                      <SHORT-NAME>ICB_ZONE_100ms_PDU00_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="16fc7c5295e43c418484f625126591a7">
                      <SHORT-NAME>ICB_ZONE_BDCAN_100ms_FrP00_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="fe72e4730e603d7bbea26235c057e989">
                      <SHORT-NAME>ICMDrvrDstcnSts_ICMDrvrDstcnSts_ICMDrvrDstcnSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c342b00d580f311ca30080ef09f757dd">
                      <SHORT-NAME>ICMDrvrFtgLvl_ICMDrvrFtgLvl_ICMDrvrFtgLvl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bfee64482afc3eacb3fc09f7f0f07f28">
                      <SHORT-NAME>ICMDrvrPrst_ICMDrvrPrst_ICMDrvrPrst_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="944ffdac1c5c3d2ab6b50e6306584943">
                      <SHORT-NAME>ICMEyeOnRoad_ICMEyeOnRoad_ICMEyeOnRoad_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de19be99237a3296b023360d57528feb">
                      <SHORT-NAME>ICMSwReq_Reserve16_ICMSwReq_Reserve16_ICMSwReq_Reserve16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e2480cd82c93f5f818dd51766606644">
                      <SHORT-NAME>ICMSwReq_Reserve17_ICMSwReq_Reserve17_ICMSwReq_Reserve17_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c97b5a5653b43cb6ba0465032eaf7c17">
                      <SHORT-NAME>ILBRReq_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9738acb3eaa73c628e721cb37a720f78">
                      <SHORT-NAME>ILCActvnDircnDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c458772a27203bd884398abc3504873b">
                      <SHORT-NAME>ILCActvnVelDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5a6c7b23dd03ec986018df5060c8313">
                      <SHORT-NAME>ILCSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30a875cda8cc30cc9bd63b442ff27e8f">
                      <SHORT-NAME>ILCSwReq_ILCSwReq_ILCSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="382dca8fc00f31f9aa90b783de29747f">
                      <SHORT-NAME>ILCSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="120171bf303a336f8bc656174867a2a8">
                      <SHORT-NAME>IMATESysSts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eae50c94d40030d38e243673855d45cc">
                      <SHORT-NAME>IMM_50ms_Group02_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37f82079dc2f3dd3836ba15cb02a9603">
                      <SHORT-NAME>IMM_50ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c32dbab470363e5eaa56c34841c31272">
                      <SHORT-NAME>IMM_50ms_Group02_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84a2fb0d2b2f3dd4babb608885e570b8">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c51ff85d9f143ff88fd84fed8d4edcff">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved143_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="122ae1897707346598699886f625b951">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved151_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="014f734d3832369ba0bc76154516754f">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved159_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba0b212c451938aba50787b98f152a37">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ce7e39446ec3fba8dd3ec7bf1fcfa80">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9d76cbaa9d130c898192774f38db035">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="918cca410cf23dbb8af440a17214ca51">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51c79e56de883431a579b9c4f169eed5">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b462ea68222c3c8d9977e8d67ca594dd">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97e7dcdbfd4232c2882edb4b3fabf010">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="16d89c42543836ea8e6c678fdfd6472a">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb46612cf8243ad9813fcacb5e06fd63">
                      <SHORT-NAME>IMM_50ms_Group02_Reserved9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="eca571fdfee830c4ab77af977c500dc4">
                      <SHORT-NAME>IMM_50ms_PDU02_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="23fc5cae173631e9877b037cb260634f">
                      <SHORT-NAME>IMM_50ms_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="4711119b158d37aaa0f3f5a0899a9548">
                      <SHORT-NAME>IMM_BKPCANFD_50ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="54a7438473ae31e8be8e33f3b767b3a9">
                      <SHORT-NAME>IMM_BKPCANFD_50ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1bec5220813a310c90973771707ed04e">
                      <SHORT-NAME>IMM_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="2caf3ec3fbf23457a81b1e5ed5777b06">
                      <SHORT-NAME>IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPDAVCamrHeatReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65cc1ec2b98f3443af023916659020a4">
                      <SHORT-NAME>IPDAlgFlag_IPDAlgFlag_IPDAlgFlag_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="32eff8d60b3d30149d33bf8f1fbc77a5">
                      <SHORT-NAME>IPDAurixTemp_IPDAurixTemp_IPDAurixTemp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7fd0053a2d4034b283a96bd1915ea5c0">
                      <SHORT-NAME>IPDComKeyEnbResp_IPDComKeyEnbResp_IPDComKeyEnbResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8ee2e0a18b39321bbd8896a1bd9bdea6">
                      <SHORT-NAME>IPDDataId_IPDDataId_IPDDataId_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4df2d157e4073c8f8105b2aa5d1d773f">
                      <SHORT-NAME>IPDErrorCount_IPDErrorCount_IPDErrorCount_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="afa4f8aeddc037d2a41a22cb247dab9f">
                      <SHORT-NAME>IPDFailedReason_IPDFailedReason_IPDFailedReason_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ea55f17e00b3885b2706cf5c266c16f">
                      <SHORT-NAME>IPDIdentityResp_IPDIdentityResp_IPDIdentityResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ac2fad70794832ad94ecfd43ab2e9aec">
                      <SHORT-NAME>IPDKeyStatus_IPDKeyStatus_IPDKeyStatus_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b3aab9720eb037d0ae39c0a5447983b1">
                      <SHORT-NAME>IPDMCUTemp_IPDMCUTemp_IPDMCUTemp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3e11c22f0633a008e4764b3675fbdcd">
                      <SHORT-NAME>IPDPCBTemp1_IPDPCBTemp1_IPDPCBTemp1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ea5a2b0ad7036e3ac6b34a70cc3a5cf">
                      <SHORT-NAME>IPDPCBTemp2_IPDPCBTemp2_IPDPCBTemp2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="061726913eed3df688b7426f2a591602">
                      <SHORT-NAME>IPDPMICTemp_IPDPMICTemp_IPDPMICTemp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed4d385336ee3472bd200a6b34596831">
                      <SHORT-NAME>IPDPowerFailSwReq_IPDPowerFailSwReq_IPDPowerFailSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec768a34a8fa360d9f2d1bbbd118cfe1">
                      <SHORT-NAME>IPDResetCnt_IPDResetCnt_IPDResetCnt_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3a09ffba6023289ba0a44b628ad44a9">
                      <SHORT-NAME>IPDSOCTemp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="106be9d2816134ce9cf8e5e08cfa3db2">
                      <SHORT-NAME>IPDStsResp_IPDStsResp_IPDStsResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="98b6aea395d630ee90be5af61cc7f788">
                      <SHORT-NAME>IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPDThermalWrnngLvl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b7bd088698a3064be9e2133d371081f">
                      <SHORT-NAME>IPDTripCntResetResp_IPDTripCntResetResp_IPDTripCntResetResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a580f5202293030a9288d7afc1b0d88">
                      <SHORT-NAME>IPDTripCnt_IPDTripCnt_IPDTripCnt_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d6c861afc243c2f9580348914f31a47">
                      <SHORT-NAME>IPDTripNvmTag_IPDTripNvmTag_IPDTripNvmTag_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0360d47d44e63f3f8ded8a6de25fac79">
                      <SHORT-NAME>IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPDWtrClntInltFlwReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fbb590de5c26350485dd076b3c15d9d5">
                      <SHORT-NAME>IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPDWtrClntInltReqFlg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fbc367ad06063874ba40f596af9d6d8a">
                      <SHORT-NAME>IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPDWtrClntInltTimeReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="8815ccd30ba1355e9650323e524cd4f6">
                      <SHORT-NAME>IPD_100ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="bd026859928731cfa97fd3f4accb170b">
                      <SHORT-NAME>IPD_100ms_PDU124_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e69f8a88638d3bb78ea52dbfef8e64b1">
                      <SHORT-NAME>IPD_100ms_PDU127_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8bf61632f3093e4299e853cfccc2189b">
                      <SHORT-NAME>IPD_100ms_PDU128_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="df13beb910a93c399f2bdbd433131101">
                      <SHORT-NAME>IPD_100ms_PDU130_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="95877bc7bbad3636abd198127254635c">
                      <SHORT-NAME>IPD_100ms_PDU16_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="95fe75315f0e3a11832baf3030c3cc45">
                      <SHORT-NAME>IPD_100ms_PDU35_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="eed18b4faebc3d5590c1f8fc31d914f7">
                      <SHORT-NAME>IPD_100ms_PDU50_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5e48e0f014cd31d99d27a280a23c5be2">
                      <SHORT-NAME>IPD_100ms_PDU58_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a53ddc040def3e4d94f71ff0a83c13d9">
                      <SHORT-NAME>IPD_100ms_PDU61_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d11f73c98ea638e5a962c2ad5e1c8f17">
                      <SHORT-NAME>IPD_10ms_PDU59_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="97be27ef09b8372cbff283ec10d04751">
                      <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d318b3219cbf314792fedd8f4104b9c2">
                      <SHORT-NAME>IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd4380e04423330290e61e680911873d">
                      <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec52279d990235b993075de976edcc85">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e5bcb59d10634c48c278a6db94ea7b6">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a3347d003bdb3313b9aebb974bcaaf71">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b90825416f7313093481b92c9fc6f86">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a5fe0dd4cf53923a2abe63f6c6b9f7e">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="64fc9d0c95cb396d91ddbb5b0363b7e6">
                      <SHORT-NAME>IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="adce799c3c4439cb9ca47d22840749f5">
                      <SHORT-NAME>IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="43f2242a0c593597a94376d8b4188150">
                      <SHORT-NAME>IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74b2e941af1d39efb836a2937339ab66">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved10_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e880485665873cc68d2f51ab4e52f433">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved11_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f56eac974fb03c5794b0e2cb7fed6179">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d2c984c10e203485a5ca380b51050c63">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22e76a4cf425398183157c847ac0e6a4">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="430719495d573b308725e9c60bc6ba07">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53381d8f438f3fad9ffd56841ce964f0">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="081559c7938830d1a5f9d7709ce4ca34">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39201f8b755032c08f148f2eb1029a1c">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b441d6b6d98a3362b5bcdc5599d9179d">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved9_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4eb0cc8d1f8d305b95c7713f2bfc3c34">
                      <SHORT-NAME>IPD_20ms_PDU43_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f2e5494fbb5b332a93748274106b753c">
                      <SHORT-NAME>IPD_20ms_PDU60_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="f3c4b76aa44637d19bd7fd453d2f01a8">
                      <SHORT-NAME>IPD_50ms_Group14_CRC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="157e41d7aeb831f9af8b955f1e385620">
                      <SHORT-NAME>IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d5c61b26a463ba3b869c3d03462db8d">
                      <SHORT-NAME>IPD_50ms_Group14_RC_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f629ad9c59603315bf90b3b956b273b8">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved10_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99c20bbc2fdc3a35b7ed476ebd9d0611">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved11_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da147db99db23826b6f88e0ca5f8aeb0">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4be290be5e943d27a0ed9591596f12c0">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f39ddf5ced434229e4a2286ca1bfe2c">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89287e7e8dae307c939b2066a445aabc">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="180cfda0409b338aa1350f83890c7cb1">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e4afc9c4ebcd302bac85bb568fc77885">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b898f0b134f737bca3f9e4b230b6f8cc">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a6108b2e8f135949881ce84583a2ecd">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20d81522477038cfb0fff46413eadf95">
                      <SHORT-NAME>IPD_50ms_Group14_Reserved9_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7a13351954837e7b377b41d2c73d8dc">
                      <SHORT-NAME>IPD_50ms_Group49_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="925bdd7dd7373752be446b49eadde93c">
                      <SHORT-NAME>IPD_50ms_Group49_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c7275d6595ff326ebb762bc2c21275be">
                      <SHORT-NAME>IPD_50ms_Group49_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d8c97c4d5803255bcbf54c50427fe8e">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bc8ae31559d335c9f296b363848131c">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34f120b2d15d3145bd8c71f1eebabcf7">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2407f90be14c3dc49ad825add2be6bbc">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fd1b9c2a322b354f82721ca90c471f19">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d183f1b8a5a38eaac448fc5453a548f">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4b93e5a6623a32fda916deec47892004">
                      <SHORT-NAME>IPD_50ms_PDU14_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="fd423f23d7b13f9aadcb30b9fe1a6ce8">
                      <SHORT-NAME>IPD_50ms_PDU49_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="2f8b111e12383edaa2bb8f336d4abf0c">
                      <SHORT-NAME>IPD_BKBCANFD_EvtInfo_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="bc8357031b6f39f6994097b2e7d9a17c">
                      <SHORT-NAME>IPD_BKBCANFD_EvtInfo_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="29d00a0be9e73318be91164b88109f65">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP124_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="680200339ee93da4a3e18ba9669d79c8">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP127_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2c161971119d3bde9faab377bfa97573">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP128_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="035b74b1af453a71a9ee9062ebbac784">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP35_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5deae11b23823d4ea77fb1d5adb09906">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP50_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b1bd853174c234638f769380f67927c4">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP58_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d09be487f81e3229a1d80d25de3bdc46">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP61_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4a662a96c8393ac4a8502de55fd671dc">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_P31_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="87eefddd2cfb3f0db79a4d659fe7dcd5">
                      <SHORT-NAME>IPD_BKPCANFD_10ms_FrP59_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2e6754c0bd1138a28af126ae4748487d">
                      <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="60823b550b633efd9d904df66a6d5543">
                      <SHORT-NAME>IPD_BKPCANFD_20ms_FrP60_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9de952b1ae1c3e788b7a25806c5599c5">
                      <SHORT-NAME>IPD_BKPCANFD_50ms_FrP14_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="3f676c807e0735f591fe1fdd416b3361">
                      <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b6beab97d4823d83b66fdc5879d86a7f">
                      <SHORT-NAME>IPD_BKPCANFD_Event_FrS01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c050fba756803bc99789a96166c0c511">
                      <SHORT-NAME>IPD_BKPCANFD_Event_FrS13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="60d24ec6e3ea30cc8b327fd5002e6425">
                      <SHORT-NAME>IPD_BKPCANFD_Event_FrS35_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4950b7ce5d35335699872b7285d974b2">
                      <SHORT-NAME>IPD_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c1a59dbb2d753c36b18440ca4b761254">
                      <SHORT-NAME>IPD_CHCANFD_100ms_FrP130_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="eb4805621c413626908de2c3258e9afc">
                      <SHORT-NAME>IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_NKI_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5aecf195e2a131a59953f0fda2c5cbd2">
                      <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_NM_BSMtoRMS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0bf687757dbb3d8c9830a9d66eb6745f">
                      <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_NM_NOSSta_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af2d6fceda4433b2a994ae786c3c0825">
                      <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_NM_NOStoRMS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="896116803f54317a9dea803f20a72908">
                      <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_NM_PBSMtoRMS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a280ec95362533d498e3d2e61432d7a1">
                      <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_NM_RMSSta_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4cdc78476fdf32bcb0e64e390fa43fce">
                      <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_NM_RMStoNOS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef05a53c65ca317b9c66a831be29001f">
                      <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_NM_RSStoNOS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="17474a1afbb53aae8908f9aceaa7c373">
                      <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_NM_RSStoRMS_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="053f84180de635cb946d95113e634a70">
                      <SHORT-NAME>IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_NOI_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6a6fa392d3f3610a008faf680514239">
                      <SHORT-NAME>IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_NWI_BKPCANFD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="1768a475f2a33e15aeb9566794320b20">
                      <SHORT-NAME>IPD_PTCANFD_100ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d1237c8067053eff934b856967eb62ae">
                      <SHORT-NAME>IPD_PTCANFD_100ms_FrP16_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="cb94edf7f3da3c6eadf53dd935f21886">
                      <SHORT-NAME>IPD_Sporadic_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="16ffee17bfb7368ab4ef40caeaab1fb6">
                      <SHORT-NAME>IPD_Sporadic_PDU13_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8873a790f9f03181b983c66a492b3150">
                      <SHORT-NAME>IPD_Sporadic_PDU35_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="b0e329c1d01a3873afa7530fffd8909a">
                      <SHORT-NAME>IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_Sporadic_TimeSync_Group_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e8d6ce468883606a42b4042bca83da5">
                      <SHORT-NAME>IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_VehLckCtrlReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8604f3423e263805b0fb7ef3362f4d46">
                      <SHORT-NAME>IdentityChlg_IdentityChlg_IdentityChlg_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="741783dec7ba369ca9dbb5ddebdb8710">
                      <SHORT-NAME>JAMsgReq_JAMsgReq_JAMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e81e73fe52323ffc808efa4c0180ec39">
                      <SHORT-NAME>KeepPwrRsnIPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38121d6ff1f2341f8f14689b9e1e8c39">
                      <SHORT-NAME>KeyAuthResp_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="48a54873211637adaad668f81a9ab401">
                      <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49b12b88622b30ddbe06a07530fe4bd7">
                      <SHORT-NAME>LADSCurToEndPntDist_LADSCurToEndPntDist_LADSCurToEndPntDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7fbc988303f3f9092d06b49ee5afbe3">
                      <SHORT-NAME>LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_LADSInfoDispReqToICM_HPP_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce0691fe92c13d37b13b5e9277fcd99d">
                      <SHORT-NAME>LADSInfoDispReqToICM_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="351f147aa31b3946845ed09b7b5d37c4">
                      <SHORT-NAME>LADSInfoDispReq_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37cb34193f4a37e2afa60b479b912456">
                      <SHORT-NAME>LADSProgressBar_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b0ba42682ffa3798b31f41af4562c592">
                      <SHORT-NAME>LBSDAndLCAWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8581a7775af43fa3873ffa35aaf833ea">
                      <SHORT-NAME>LCASelReq_LCASelReq_LCASelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="198de4e909773d88b8f09362f6d1f504">
                      <SHORT-NAME>LCASelSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e6ad2c2c7c3343ba01d3a7ff99f557e">
                      <SHORT-NAME>LCRInHMI_LCRInHMI_LCRInHMI_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83a2a84273a437c5a76cec2df025bc84">
                      <SHORT-NAME>LCRSwDspCmd_LCRSwDspCmd_LCRSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae2500ebe3063ebb9b2aad2d00a385df">
                      <SHORT-NAME>LCRSwReq_LCRSwReq_LCRSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="111addf2568c3535b7e645d57471cd51">
                      <SHORT-NAME>LDOWWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d355254f6212362eb2032b7a401a8dac">
                      <SHORT-NAME>LDWAdoWrnngDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b09d62d7e0c73c5bacc46a92b03f8e00">
                      <SHORT-NAME>LDWAdoWrnngReq_LDWAdoWrnngReq_LDWAdoWrnngReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b454681b2342388d85688ab98999797d">
                      <SHORT-NAME>LDWLKAAudReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4303b9f9f873a35a59eb20b275a9d6d">
                      <SHORT-NAME>LDWLKADspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9b1954ec6b9357f8642c8d2b63d61b7">
                      <SHORT-NAME>LDWLKAHptWrnngDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca5c3ddf9dbd30ffaccbe61f261e8a32">
                      <SHORT-NAME>LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_LDWLKAHptWrnngReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="991b620258b93a17b5854c746ee3cf30">
                      <SHORT-NAME>LDWLKALVsulznReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="95cc4edfabf23c319551d95a5ba4f64a">
                      <SHORT-NAME>LDWLKARVsulznReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="95952a3f7e803d1483ff99086481a718">
                      <SHORT-NAME>LDWLKASwReq_LDWLKASwReq_LDWLKASwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d56175f0eac63957a9ebdd7369332b11">
                      <SHORT-NAME>LDWLKAVbnLvlReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="523588400f613c96a2ce2714106fe49f">
                      <SHORT-NAME>LDWSnstvtLvlReq_LDWSnstvtLvlReq_LDWSnstvtLvlReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4645425901bc3643a8b6b31bbed903c4">
                      <SHORT-NAME>LDWSnstvtLvl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f3c420ab3e13e329cc0ac3ffd3c2d8f">
                      <SHORT-NAME>LDWSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ed735d6dc0b3482a2145993e2df92b1">
                      <SHORT-NAME>LDWSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8498ccef09434488f987c01d98e9626">
                      <SHORT-NAME>LDayTimeRunningLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5e9bb4d9d243cc69a21de7563178e0a">
                      <SHORT-NAME>LFCTWrnng_ADAS_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f0fd7800bd9137e4b9a597d328921057">
                      <SHORT-NAME>LFCTWrnng_LFCTWrnng_LFCTWrnng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="947280b02a643b13bdcb276bd9c5986b">
                      <SHORT-NAME>LFSDA_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2462351c8f0737dc9425a742d8e470bb">
                      <SHORT-NAME>LHRDA_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="bab0cbe6b62a35d6805907ee56e3d4ce">
                      <SHORT-NAME>LHSWPwrSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="169ac86dfd693264b92d15aa1495333b">
                      <SHORT-NAME>LHZCUAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fcdcd83bb0dd3763ac1a60d42e3e4b1a">
                      <SHORT-NAME>LHZCUWKSTS_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f494a1f842403ad6a19bf61518a7820b">
                      <SHORT-NAME>LHZCU_100ms_Group30_CRC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7fdaab2265873f158da68b0afedebe90">
                      <SHORT-NAME>LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="553e932b9ecc365485f790662ac8545e">
                      <SHORT-NAME>LHZCU_100ms_Group30_RC_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="57a77519fed73b55ab27ffcee6d11259">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved103_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e9a4b4d0599392a8265cd8bca6eeee8">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved111_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5122a028b6c13d1fad654b9ae374eed3">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved119_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6076132786c324890ed2ec6091f04ff">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved127_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8c348778ed03acfb74034ac5306480e">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c2e5a8d9a7c3415acc7f97f6a8622b9">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved23_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9806a1dd9dd539009f82f1c9b5cf16d4">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved31_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f0e5a1486e53222a795e9532248a16c">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved55_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9897a6ea947e3b45a9ee4e10317b946d">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c511a5e255233ef962ac4307e2765ab">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved71_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2de8e393cac531e3aed957b2a7f2318a">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved79_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e98ff197844d3dd3ac91f055cc61c5ab">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved87_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="973737575c593ea2aff3f13be86259de">
                      <SHORT-NAME>LHZCU_100ms_Group30_Reserved95_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="b1cc9e08ec0034c491ad903e8663109f">
                      <SHORT-NAME>LHZCU_100ms_PDU14_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="11645477372b36c69f1c71301f58c1af">
                      <SHORT-NAME>LHZCU_100ms_PDU15_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="039deb0631fa30249bfbef34f54324ef">
                      <SHORT-NAME>LHZCU_100ms_PDU16_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f39358dd9c223a6aa2685bd46bca4d3f">
                      <SHORT-NAME>LHZCU_100ms_PDU22_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cd4e1b1ea2e43a3a8b10812e1b4b3e07">
                      <SHORT-NAME>LHZCU_100ms_PDU30_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="e67ef46e293031b7aa96f5dcc7d3a593">
                      <SHORT-NAME>LHZCU_10ms_Group01_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae7e62ded98c3a1fb5c40539d8bf629c">
                      <SHORT-NAME>LHZCU_10ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c21342ae7963f70a3714f97c1d93945">
                      <SHORT-NAME>LHZCU_10ms_Group01_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7103ae94f3039299bc32976bff745c3">
                      <SHORT-NAME>LHZCU_10ms_Group01_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd8d193ff261369381e5bf5918844eb7">
                      <SHORT-NAME>LHZCU_10ms_Group01_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7a94bad57a235bbb7e4feb017e874e7">
                      <SHORT-NAME>LHZCU_10ms_Group32_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a25a36e5ef393a19b27331febaad197c">
                      <SHORT-NAME>LHZCU_10ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ddcd8f93a773588a1eaaa8b1ddec4e3">
                      <SHORT-NAME>LHZCU_10ms_Group32_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="60420d9f21cc3c5caf707380a586b1e0">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b145a6f89603352b9773e643db65e6f1">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a01fe2d7cad2307498323f77bbb9cb30">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ef48184462a389fb971a1f954c83dca">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="62d62880cd5438c3aad5a549f6b25a0e">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae6e3fa282803d699f4dd6bc047157c6">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fa42dfc5ffe238af9e50aa5003ded70b">
                      <SHORT-NAME>LHZCU_10ms_Group32_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="9983301c847632fe9825c45bc3b89b8e">
                      <SHORT-NAME>LHZCU_10ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3b413dbd68fc37ee86acdfed44d3706d">
                      <SHORT-NAME>LHZCU_10ms_PDU32_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="96a37275be5f348b9148f17c4389f3a6">
                      <SHORT-NAME>LHZCU_20ms_Group03_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="919ae205b2873a199348ecc7488bea7a">
                      <SHORT-NAME>LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ff980e9ec5333b197cefe160d46a577">
                      <SHORT-NAME>LHZCU_20ms_Group03_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20a5cc35505133b8a16379d522922f13">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6afa5a8667f430c583c74f7eb0a264c5">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54163ce042a23452ba8e7a662689b539">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54dc994c6da43842900752871531e8c0">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb1b3e6a81b8319ebeddbe665ba8ab47">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8943e15bc776333692cf1e5fbedd0273">
                      <SHORT-NAME>LHZCU_20ms_Group03_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="1dabc2c2e70038729ba0a1a3ed5fdd6b">
                      <SHORT-NAME>LHZCU_20ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f4ce01e1fbf03b50a50122e2db980050">
                      <SHORT-NAME>LHZCU_400ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="fb2928491779358e87f50253ad4f7791">
                      <SHORT-NAME>LHZCU_400ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="140bb42d93803032b497bdddb9de76c8">
                      <SHORT-NAME>LHZCU_50ms_Group06_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65a9e03b839139e0b31343d84a795106">
                      <SHORT-NAME>LHZCU_50ms_Group06_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="01aec3f2f4cf323c968915fc46d817ca">
                      <SHORT-NAME>LHZCU_50ms_Group06_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="537daff8b36830ac8a815ac2fc7cdec2">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="92a5339e9b593b35919b0e86a67226b2">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0965c72c09f136d5a75e21fce258e7d0">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa6f5b416e3636cb953b62cd8b938aa9">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0ebbe537fac3e148367191b0c5fd5b6">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="320afe7460b336479705c8804b0099c6">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88839c3631ae37a5b7cd7ab3bf77c45a">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="062313ecfc2031c5b7d9393f04cd48e5">
                      <SHORT-NAME>LHZCU_50ms_Group06_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9585f3b4cef13f78838f3c282fb969d7">
                      <SHORT-NAME>LHZCU_50ms_Group24_CRC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2bd0722b340d3d34969753eec6d613ac">
                      <SHORT-NAME>LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="15dc7fa49eda3599b49c6d43c20982e3">
                      <SHORT-NAME>LHZCU_50ms_Group24_RC_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="43d5a5c9a13c319d837045f5e939e1cf">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved103_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6351de1a41663700854be9533c909c45">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved111_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e1554a72efe33cddb6536d5ce5f4429d">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved121_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="23fde0c739573b7fb433aceca396af4d">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved135_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59c7eecb03713f67b8f4b3d3f2ed4526">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved143_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1839466ac5a83d21a2c910ba175f7a9f">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved151_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2cd662872c973a5fb4064a88231098d3">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved159_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a3b86fa32fc431728500a62311ee4771">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved23_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="241339028e653d5dbb87f5d1c8e94ea7">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved31_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="525edbfdd2583a3191f3c68bad59d7b8">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved39_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="608de7c075973566adf0c952780002b4">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved47_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1849bc294a90356f92e3dfa3b13a73f2">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved49_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d586f03fc403f879763a31a253547ff">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved55_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30e29491b5633a358e5634aef9880091">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved60_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c9185d2e9ca3fd5911a7d8a5bb9ca94">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved71_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="026dc91a7bf034b28e1803b4e7ee0b15">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved79_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3f75a1a315e328e9dda2a1d72ffa2c5">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved81_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a0d78689a9ee308cb69e720ba021671a">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved87_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb8d5e24a80136518abead7963e6a326">
                      <SHORT-NAME>LHZCU_50ms_Group24_Reserved95_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="51f08b45686c367a9a2391e031539459">
                      <SHORT-NAME>LHZCU_50ms_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d8143cf36f6b37bca7af93ab0c8f25d0">
                      <SHORT-NAME>LHZCU_50ms_PDU06_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8d386c92248732db9e7e316d24d60f50">
                      <SHORT-NAME>LHZCU_50ms_PDU08_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cf05f3cdf97c38abb321fbfbec8af351">
                      <SHORT-NAME>LHZCU_50ms_PDU24_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b1416a2be13b38bba8f9d5dd977b35a5">
                      <SHORT-NAME>LHZCU_50ms_PDU34_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="98f4260976df337ca05bc6cb697525dc">
                      <SHORT-NAME>LHZCU_50ms_PDU58_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="5ff6c2e22279310180a3be414e608a2e">
                      <SHORT-NAME>LHZCU_BKBCANFD_100ms_FrP30_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="70af967786343aebba39bbeb6653fa16">
                      <SHORT-NAME>LHZCU_BKBCANFD_10ms_FrP32_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="39dd3cad91d9357a827c2924699c188b">
                      <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="33aa6a07dc8438c08e629d9001a6d6c8">
                      <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="534066fed33239519fbbf793b610b2ca">
                      <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP24_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="45bc1f4eb54f3deca60ebb37268d2054">
                      <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP34_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5a3cb3927a363b64bb2d345250fb6b1c">
                      <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP58_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="49606bc7975b3c73926e0c6172c94160">
                      <SHORT-NAME>LHZCU_ICBVC_50ms_PDU14_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="f0d612b4e2f23c548aeda361cbbbef06">
                      <SHORT-NAME>LHZCU_ICBVC_LHBKBCANFD_50ms_FrP14_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="51399b619c863d8c8ce8f90f814113e0">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP14_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a1e5367538b93ed0ab36ada6f6c11b95">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP15_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="06d7d5a6dcfd32bf81210ef2c9d88ad6">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP16_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="bedc2665ccf03742afc1c4f48e943d1a">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP22_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6c1eb1f560123c17aa4123baf53e2553">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_10ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="87bcbdb6bbce35ca8eb9ed87cd2a4b50">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_20ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0a131c9ab3b83550a9dedbf54999fcae">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0d65ffdc52c13f5882a2ccc193001e18">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="149f88a631d83d95bb2a8ead83dae89d">
                      <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="51a4ad6ebbee3629b5a55c71c0666378">
                      <SHORT-NAME>LKADrvrTkovReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bdb7ae9283113a7a81431c8e52ed903a">
                      <SHORT-NAME>LKASysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="914293d4628b3ada885ac38b6114b75b">
                      <SHORT-NAME>LKASysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0998d4b992f733abaceb954ae21e121f">
                      <SHORT-NAME>LMainBeamLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cc8d782fc0523f0d8b14169ae409766d">
                      <SHORT-NAME>LRCTAWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cef76e474a713f81874af4692267111e">
                      <SHORT-NAME>Lane0_C0_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbe86f9352d139688dece2b3c0536137">
                      <SHORT-NAME>Lane0_C1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ac922720d5e5325e9632912b77dd3d42">
                      <SHORT-NAME>Lane0_C2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="01d6d2a24c4739ec97d635085738b5a8">
                      <SHORT-NAME>Lane0_C3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0387ddc3e7e83c768b427d934496bd2a">
                      <SHORT-NAME>Lane0_ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50ca463498cb3a9da3fd21c137869fa5">
                      <SHORT-NAME>Lane0_ID_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cf6293870cf739b6be84147f534d8cda">
                      <SHORT-NAME>Lane0_MarkerColor_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45de99cbd2063c31a661ddb14bf8c756">
                      <SHORT-NAME>Lane0_MarkerType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a97038df65b63bd7aa790b99452c44f7">
                      <SHORT-NAME>Lane0_Part0_SyncFrameIndex_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e45d70667c4133829623b25399c794c9">
                      <SHORT-NAME>Lane0_ViewRangeEnd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c79af3808fc37668a9afed9fbe33bde">
                      <SHORT-NAME>Lane0_ViewRangeStart_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bdb4436f89ba3fc791c717109179be81">
                      <SHORT-NAME>Lane0_location_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9ee2ad9aab2314383027e639e86b69a">
                      <SHORT-NAME>Lane1_C0_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="306b931e4af6352a8c81e8e65a44f3a8">
                      <SHORT-NAME>Lane1_C1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eeb13bb0ce4738cab25d3657aa402da4">
                      <SHORT-NAME>Lane1_C2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c00d01f448383352803fab3d62234e68">
                      <SHORT-NAME>Lane1_C3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab6065713f033962936c8d36ec62723d">
                      <SHORT-NAME>Lane1_ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5fb121404ba325db053f82a2db6730b">
                      <SHORT-NAME>Lane1_ID_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b39bf1d779b3915b0a1ef47325ca915">
                      <SHORT-NAME>Lane1_MarkerColor_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d7560485b7fb3b9abade0bad5fddc7fa">
                      <SHORT-NAME>Lane1_MarkerType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52fc8fab647a3b0cb348aff875501912">
                      <SHORT-NAME>Lane1_Part0_SyncFrameIndex_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af04cecf888f3d70a11a8bf705160c54">
                      <SHORT-NAME>Lane1_ViewRangeEnd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d24a4eb010cc35baa94292353ba50f42">
                      <SHORT-NAME>Lane1_ViewRangeStart_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c2bfe1cd5043e97a545476494175784">
                      <SHORT-NAME>Lane1_location_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c4ac6e7686873878ac1ec50a296f8e19">
                      <SHORT-NAME>Lane2_C0_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97a1f12e6fc03fd2aeb8173bd5ae230d">
                      <SHORT-NAME>Lane2_C1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5195c612c73f3b8e83cc18ae88912531">
                      <SHORT-NAME>Lane2_C2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ee3524e958a3b99bfa2f57012be4989">
                      <SHORT-NAME>Lane2_C3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="889c87f436e3398285f11a2429b68c17">
                      <SHORT-NAME>Lane2_ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="daf99acdc17232f7a7410847b49a2370">
                      <SHORT-NAME>Lane2_ID_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="71a7518fbd2639a5ae7e061d767b0676">
                      <SHORT-NAME>Lane2_MarkerColor_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="105e82f3eec130218466c9664d4f4b0d">
                      <SHORT-NAME>Lane2_MarkerType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e32604152743cb6b9abb4a85ffb45cc">
                      <SHORT-NAME>Lane2_Part0_SyncFrameIndex_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31ce6c2b93703b20a32fcf4445a7171e">
                      <SHORT-NAME>Lane2_ViewRangeEnd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2aee32f5b8583f6d9ceb196663fb2585">
                      <SHORT-NAME>Lane2_ViewRangeStart_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94b742b4a0c13b458f79af24870e27b3">
                      <SHORT-NAME>Lane2_location_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fa8342d48f9f33638d22733280dccd0a">
                      <SHORT-NAME>Lane3_C0_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3470f227fe9a3840b87e82cd3afb47ce">
                      <SHORT-NAME>Lane3_C1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="56f7b1bc214030629e03b3c8560bfc67">
                      <SHORT-NAME>Lane3_C2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3ecbea6f86323a0a8bded1b2e58f9147">
                      <SHORT-NAME>Lane3_C3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e942ff9e49013bb385867514f9c220c2">
                      <SHORT-NAME>Lane3_ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="03d7d536e4e730508e38edb1b7e0a646">
                      <SHORT-NAME>Lane3_ID_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d5e8bbd09413e07af84b28e1cd6b0f2">
                      <SHORT-NAME>Lane3_MarkerColor_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f51627ca5d053321bd8dc0a6a8e098c1">
                      <SHORT-NAME>Lane3_MarkerType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="882a6d7f6a2b3a45b7a197bc19ad0fc7">
                      <SHORT-NAME>Lane3_Part0_SyncFrameIndex_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b87457e7c4f83864ab47a245f4e59fcb">
                      <SHORT-NAME>Lane3_ViewRangeEnd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c0c930271643d9c86bbd548672815e5">
                      <SHORT-NAME>Lane3_ViewRangeStart_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e6ab55d353a3550b3260910719850fb">
                      <SHORT-NAME>Lane3_location_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0722b6288e333d1ab36b7744d5d1cb2f">
                      <SHORT-NAME>LatSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="669561f5e3e83144ae041b4acfa1ba7b">
                      <SHORT-NAME>LatitudeRTK_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e038973b64f3c19ad7c14f58659dac7">
                      <SHORT-NAME>LdspcOpenStsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b322b852ef73c5d9d2da33d3cff2bff">
                      <SHORT-NAME>LdspcOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e03019b6a50f3ab88f21cfc6a947b5f8">
                      <SHORT-NAME>LeftEyeOccludeStatus_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="995ae3bd4b543fea93498f9d75656553">
                      <SHORT-NAME>LonSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e18d9da7f19339e0905dcbd4518eef7e">
                      <SHORT-NAME>LongitudeRTK_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b54c96b4c7033b218698828105445709">
                      <SHORT-NAME>MainBeamLghtOn_MainBeamLghtOn_MainBeamLghtOn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="677b4916cb9333af811eff520d71a106">
                      <SHORT-NAME>MainBeamLghtSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e4cdfa0c942731d8badbc76c8aa0d141">
                      <SHORT-NAME>MdOfPwrMd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d6b5f0f8758736e689fec7b2c5b8f5d6">
                      <SHORT-NAME>MemParkngBtnRcnm_MemParkngBtnRcnm_MemParkngBtnRcnm_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38ab8fc40bf3304cb69ffd16cfaf3beb">
                      <SHORT-NAME>MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_MemPkngSlntPtrlEnbSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5823d93a251335d49e47b599dad50669">
                      <SHORT-NAME>MemPkngSlntPtrlEnbSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5d9fc8f18f636daaa6b95b823dc97dc">
                      <SHORT-NAME>MemPkngSwReq_MemPkngSwReq_MemPkngSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b05f9dfccdac38c1b677a627b5bc0452">
                      <SHORT-NAME>MemPkngSwResp_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1dcfa3c301003487aa058757e12cf091">
                      <SHORT-NAME>MnvrngPntDistNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91213a5c9338389686d457b8997aff6e">
                      <SHORT-NAME>MnvrngPntTypNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c48724f1a9d13081b8697e1b56fc6698">
                      <SHORT-NAME>MouthOccludeStatus_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8313efe896d3018ae819147cfbfef37">
                      <SHORT-NAME>NOACitySysMsg_NOACitySysMsg_NOACitySysMsg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e49431a447b0330e8d46d05031f589ac">
                      <SHORT-NAME>NOADistDecMsg_NOADistDecMsg_NOADistDecMsg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f66248eee9c432e8a80872e4f69894e0">
                      <SHORT-NAME>NOAETCSetDspCmd_NOAETCSetDspCmd_NOAETCSetDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5919be5804f35478cd23b44f4ce8a1b">
                      <SHORT-NAME>NOAETCSetSwReq_NOAETCSetSwReq_NOAETCSetSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df88fc10a4a83fa18709a6088454930e">
                      <SHORT-NAME>NOALaneSetDspCmd_NOALaneSetDspCmd_NOALaneSetDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ed1ab4409d032e7b2aa7b10a8431071">
                      <SHORT-NAME>NOALaneSetSwReq_NOALaneSetSwReq_NOALaneSetSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="161bc8ab517d3ff8836cb54c01406607">
                      <SHORT-NAME>NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_NOAQukChgSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2fb6b7c58faf3b77ac0d66e233c26358">
                      <SHORT-NAME>NOAQukChgSwReq_NOAQukChgSwReq_NOAQukChgSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53e7e8fcf39f3fbe8586fe2759436c0b">
                      <SHORT-NAME>NOAReportSetDspCmd_NOAReportSetDspCmd_NOAReportSetDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec59a4524434385488924118c0fd6ecf">
                      <SHORT-NAME>NOAReportSetSwReq_NOAReportSetSwReq_NOAReportSetSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38767bea924c3ae39f40aa22ea0df73b">
                      <SHORT-NAME>NOPCitySwDspCmd_NOPCitySwDspCmd_NOPCitySwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e4ad82ab7927363db76875758ab82903">
                      <SHORT-NAME>NOPCitySwReq_NOPCitySwReq_NOPCitySwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed9f133ebff03a4e8ce28593a6947a22">
                      <SHORT-NAME>NOPSwDspCmd_NOPSwDspCmd_NOPSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f600ad730cc3441b8f5b64646ed8d25">
                      <SHORT-NAME>NOPSwReq_NOPSwReq_NOPSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a0a596ef5979396c82ba4e286b9e392d">
                      <SHORT-NAME>NOPSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f75c98344b0434eebc77d953f25e25cc">
                      <SHORT-NAME>NOPSysMsg_NOPSysMsg_NOPSysMsg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ac2149c8eec43daf85b822b8dda20eb6">
                      <SHORT-NAME>NOPSysSts_ZPD_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f3696c13f7b36fc89e99300ca17153f">
                      <SHORT-NAME>NSABacSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6258242ee6e3ea699d0fe5a903dc9d9">
                      <SHORT-NAME>NSADisFucSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d83cf3beef938f8b48b13a01b465fc0">
                      <SHORT-NAME>NSAForSysSts_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e713bdf759c53895a68ebd9fa15cc522">
                      <SHORT-NAME>NSAReqAVMDis_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d22719a935f730afab5a6967b85805d3">
                      <SHORT-NAME>NarRoVslAssQuit_NarRoVslAssQuit_NarRoVslAssQuit_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34e0f3f325a53a128553f2680801fdb0">
                      <SHORT-NAME>NarRoVslAssSwReq_NarRoVslAssSwReq_NarRoVslAssSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f873924bb4cc3018a5645b1a03f5069c">
                      <SHORT-NAME>NarRoVslAssSwResp_NarRoVslAssSwResp_NarRoVslAssSwResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c0ad81405a839e480689125f81054ff">
                      <SHORT-NAME>NarrowRoadBackwardSts_NarrowRoadBackwardSts_NarrowRoadBackwardSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="98342e21274d388ebdb96ff5a81e8ac9">
                      <SHORT-NAME>NarrowRoadForwardSts_NarrowRoadForwardSts_NarrowRoadForwardSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20d423f50b1e3ec8945d9de8f8aebe9d">
                      <SHORT-NAME>NarwSpcAstBtnSts_NarwSpcAstBtnSts_NarwSpcAstBtnSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97d62c1a042936cb9022a9fc06895929">
                      <SHORT-NAME>NarwSpcAstSwReq_NarwSpcAstSwReq_NarwSpcAstSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cdbfb20b5084300884666c5be18f3fb1">
                      <SHORT-NAME>NavCndSpdLmtVal_NavCndSpdLmtVal_NavCndSpdLmtVal_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b920314ce8c338b3809a3f91af18954e">
                      <SHORT-NAME>NavCrntRoadTyp_NavCrntRoadTyp_NavCrntRoadTyp_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b0858c1ec2b13c9e954791cc34baa6ff">
                      <SHORT-NAME>NavCtryCode_ISO_NavCtryCode_ISO_NavCtryCode_ISO_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4972497db1b33d46b38b4195f543ab48">
                      <SHORT-NAME>NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_NavDistFromFrtEleccEye_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d58e68af029e3190a7bee6c6268e2d34">
                      <SHORT-NAME>NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_NavItvalSpdDetnDistRetDist_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9281e26e4fb3bc3aa37dc0222a1fe08">
                      <SHORT-NAME>NavNewIconDist_NavNewIconDist_NavNewIconDist_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df40e6e0f92c3e9a8d4f9c143e255f2f">
                      <SHORT-NAME>NavNextRampOffset_NavNextRampOffset_NavNextRampOffset_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77520203aefc3c1f9b6a3bf5b655423e">
                      <SHORT-NAME>NavSpdLmtTyp_NavSpdLmtTyp_NavSpdLmtTyp_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26b76ba10b053e3ead97562fab298103">
                      <SHORT-NAME>NavSpdLmtValSts_NavSpdLmtValSts_NavSpdLmtValSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="80e95690b51b3783936793075c79b47c">
                      <SHORT-NAME>NavSpdLmtValUnit_NavSpdLmtValUnit_NavSpdLmtValUnit_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30bebd5979d333a4b19047cb973192b8">
                      <SHORT-NAME>NavSpdLmtVal_NavSpdLmtVal_NavSpdLmtVal_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="402b8b3214c534a1a50e7bbd65a42518">
                      <SHORT-NAME>NavSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="552d68b632db3bdc8ebab7b2640fe451">
                      <SHORT-NAME>NmPDU_BKPCANFD_FDR_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cfc48f4638a23dbea5d3ac48f53bdcf6">
                      <SHORT-NAME>NmPDU_BKPCANFD_IMM_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b5851f2bd8423b58b41121afeb4a6aa1">
                      <SHORT-NAME>NmPDU_BKPCANFD_IPD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="0bf2491075223729bad90041e86885b7">
                      <SHORT-NAME>NmPDU_BKPCANFD_LFSDA_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a35605b3202d3f7da1d8058b76fcd9a2">
                      <SHORT-NAME>NmPDU_BKPCANFD_LHRDA_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f9b218a1b14f3a5c8c5d8a4d332c646d">
                      <SHORT-NAME>NmPDU_BKPCANFD_RFSDA_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a178a45fd280374e8151db019377934d">
                      <SHORT-NAME>NmPDU_BKPCANFD_RHRDA_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ec2eb76a0fc935b8a832f7686e5c916a">
                      <SHORT-NAME>NmPDU_BKPCANFD_ZXD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="f494f49de50b393ea9ea8030a8c7e250">
                      <SHORT-NAME>NonDirectDMSSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="565b12b538743407a3bd0e8d9805232d">
                      <SHORT-NAME>NonDirectDMSSwReq_NonDirectDMSSwReq_NonDirectDMSSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65694a59491233ab819c2e7161da3c6d">
                      <SHORT-NAME>NonDirectDMSSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1bcd5266c48632698332551cbe13fc96">
                      <SHORT-NAME>NorthVelocityRTK_NorthVelocityRTK_NorthVelocityRTK_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f818da74d093c38ade34db8abddb80f">
                      <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_NrwroadBwdAssConfrmSwDscmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68031d0d95b130d7a12d3862c4515f91">
                      <SHORT-NAME>NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_NrwroadBwdAssConfrmSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2fd10f75c29f3e4696b465f701e1f235">
                      <SHORT-NAME>NrwroadBwdAssMesg_NrwroadBwdAssMesg_NrwroadBwdAssMesg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="279a1661050a30f9831c556432a79e24">
                      <SHORT-NAME>NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_NrwroadBwdAssSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38e19de70261396791ad46b86609c0a5">
                      <SHORT-NAME>NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_NrwroadBwdAssSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0ba05fbada63c48b0f701cc5db7856e">
                      <SHORT-NAME>NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_NrwroadFwdBtnDsp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0581903d853c338f8db73ffc80f6cc3e">
                      <SHORT-NAME>NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_NrwroadFwdCndNotSt_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21892d4325e33a30913a997677de05d5">
                      <SHORT-NAME>NrwroadFwdCtlReq_NrwroadFwdCtlReq_NrwroadFwdCtlReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8cf06b80faa637778cd1656d121994bc">
                      <SHORT-NAME>NrwroadFwdDsp_NrwroadFwdDsp_NrwroadFwdDsp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="15b17fb1d2123b22a656ee06924b97b5">
                      <SHORT-NAME>NrwroadFwdDst360Req_NrwroadFwdDst360Req_NrwroadFwdDst360Req_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a58e0bfcc8bb39b78ce0a5debcf8796b">
                      <SHORT-NAME>NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_NrwroadFwdDstBtnDsp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b97ba63016443b788ab3bca50a2e6d8d">
                      <SHORT-NAME>NrwroadFwdDstL_NrwroadFwdDstL_NrwroadFwdDstL_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="944c9cec7ab534769b7575068053ff1c">
                      <SHORT-NAME>NrwroadFwdDstR_NrwroadFwdDstR_NrwroadFwdDstR_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="784e36a47a593e5780e63ea8284c28e3">
                      <SHORT-NAME>NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_NrwroadFwdDstTostDsp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6e83ee425b0e347980123ae8c191d881">
                      <SHORT-NAME>NrwroadFwdReDst_NrwroadFwdReDst_NrwroadFwdReDst_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ea5dfac30ae3ba7bfb7262ac7055dfb">
                      <SHORT-NAME>NrwroadFwdReq_NrwroadFwdReq_NrwroadFwdReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7686cf73d9d93e52a1e4dfa2c68932fe">
                      <SHORT-NAME>NrwroadFwdSta_NrwroadFwdSta_NrwroadFwdSta_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b463cc2d0aa346b833d843c34fd83de">
                      <SHORT-NAME>NrwroadFwdSwSts_NrwroadFwdSwSts_NrwroadFwdSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="592bb0a31fe4341ebbf4d512985f82cb">
                      <SHORT-NAME>NrwroadsltReq_NrwroadsltReq_NrwroadsltReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="679f60fe31d3346a85f2ea974ddc24c5">
                      <SHORT-NAME>NrwroadsltSta_NrwroadsltSta_NrwroadsltSta_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f165203d9463fc6937bc05036a0c585">
                      <SHORT-NAME>OMSSts_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0de5383dd80e3828aeda79eb555fa6e8">
                      <SHORT-NAME>OdoPriyPrcsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8469c4537ce0352ca366bd43492639b2">
                      <SHORT-NAME>OdoPriyPrcs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7586565e8a5a375491ac1c7d82660698">
                      <SHORT-NAME>OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_OtsdAirTemCrValMsk_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8305912a511f34a6ad4d071ad4c80f5e">
                      <SHORT-NAME>OtsdAirTemCrValV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb646548b3bd3db7948c336e0a30a90c">
                      <SHORT-NAME>OtsdAirTemCrVal_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f13a07baf193902adbdbff57aa5fadc">
                      <SHORT-NAME>PDCSwReq_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55606750dac4360693181e1d55a9d1eb">
                      <SHORT-NAME>PDCSysSts_PDCSysSts_PDCSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce25efe7999b338782e037c23d7c7f74">
                      <SHORT-NAME>PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_PDSysKeyPsAvlbl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c23288d210a034adbba1221856724f28">
                      <SHORT-NAME>PEBSts_PEBSts_PEBSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9e5916b50d1b3f9eaafe53ce064d0193">
                      <SHORT-NAME>PEBSwReq_PEBSwReq_PEBSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="686eac39ee0d3cb09156d9122c014751">
                      <SHORT-NAME>PEBSwResp_PEBSwResp_PEBSwResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca7fc0a9b88434219362fe643a98e040">
                      <SHORT-NAME>PEBSysFltSts_ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="46b9deec79aa3cb8894ba73bddbc3ee5">
                      <SHORT-NAME>PEBWarngReq_PEBWarngReq_PEBWarngReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0ef9d8fed9e232b09ed8f6c335b76f64">
                      <SHORT-NAME>PICU_PTAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97a78931296336b4bcd1ee3ee590062d">
                      <SHORT-NAME>ParkngDirAvlSts_ParkngDirAvlSts_ParkngDirAvlSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ac764297725c3a54908d4c35413a41f6">
                      <SHORT-NAME>ParkngDirSwResp_ParkngDirSwResp_ParkngDirSwResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6baf806a88c53e26bf77decfaff32bff">
                      <SHORT-NAME>ParkngDirSw_ParkngDirSw_ParkngDirSw_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0bb10914ce883e688bf2b1e8e4fcb175">
                      <SHORT-NAME>ParkngEndDis_ParkngEndDis_ParkngEndDis_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c964be778ccc37e0ac283067b11c09d6">
                      <SHORT-NAME>ParkngInPrgs_ParkngInPrgs_ParkngInPrgs_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7954786d1af13362b67e206f1d462b21">
                      <SHORT-NAME>ParkngNCPAvlSts_ParkngNCPAvlSts_ParkngNCPAvlSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="725695aa36173c3bab5ca930e36a1183">
                      <SHORT-NAME>ParkngOutBkCrsSts_ParkngOutBkCrsSts_ParkngOutBkCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5dcbc0a1d02b33c7ac76c0ac956991ce">
                      <SHORT-NAME>ParkngOutBkLCrsSts_ParkngOutBkLCrsSts_ParkngOutBkLCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bfc88cdb165339af85184670c25bc21d">
                      <SHORT-NAME>ParkngOutBkRCrsSts_ParkngOutBkRCrsSts_ParkngOutBkRCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f532f06212b43243b04a30e61624b5ff">
                      <SHORT-NAME>ParkngOutDircnSelResult_ParkngOutDircnSelResult_ParkngOutDircnSelResult_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="154bbb4508e63184a535dd7541ea3969">
                      <SHORT-NAME>ParkngOutFLCrsSts_ParkngOutFLCrsSts_ParkngOutFLCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea3ad334474a34e5ba5a53973800daeb">
                      <SHORT-NAME>ParkngOutFLParllSts_ParkngOutFLParllSts_ParkngOutFLParllSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="805ea7894def376ea270a3556f6ea29c">
                      <SHORT-NAME>ParkngOutFRCrsSts_ParkngOutFRCrsSts_ParkngOutFRCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54764f1686ac3967b518b0ba7038a31a">
                      <SHORT-NAME>ParkngOutFRParllSts_ParkngOutFRParllSts_ParkngOutFRParllSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="46a2fa60a4733d908d74e391eda3ed46">
                      <SHORT-NAME>ParkngOutFrtCrsSts_ParkngOutFrtCrsSts_ParkngOutFrtCrsSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26d2a0148cb63455912c2c8e70f0d162">
                      <SHORT-NAME>ParkngSlotFindSts_ParkngSlotFindSts_ParkngSlotFindSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cabbe6475a03381bbaa25cde4ea9a7b9">
                      <SHORT-NAME>ParkngSpdSwResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c374bf3feeba3900a75eacc66e56b009">
                      <SHORT-NAME>Parkngslottype_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9c89fcfbb243629a8dceb3e3adc7d37">
                      <SHORT-NAME>Pdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e0e1bd3088a3c6a98362e207ffa1239">
                      <SHORT-NAME>PfTrTapUpDwnEnbSwSta_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fecfb84a6bfb3638a0a6dd0bd16f96ff">
                      <SHORT-NAME>PfTrTapUpDwnSecySwSta_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dce8617d1dab3bcf91ade5eed0079c79">
                      <SHORT-NAME>PfTrTapUpDwnSwSta_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c57652c56da93dfeaefc3a99c9f9fdf6">
                      <SHORT-NAME>PilotSysADASFltSts_PilotSysADASFltSts_PilotSysADASFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a646b3214353104a7455abb6807b113">
                      <SHORT-NAME>PilotSysAVCamrF1FltSts_PilotSysAVCamrF1FltSts_PilotSysAVCamrF1FltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b4eb26b284230e0a5c31afc707b1da1">
                      <SHORT-NAME>PilotSysAVCamrF3FltSts_PilotSysAVCamrF3FltSts_PilotSysAVCamrF3FltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="331a7423160b38ff89b1b954913bc8d5">
                      <SHORT-NAME>PilotSysAVCamrFLSFltSts_PilotSysAVCamrFLSFltSts_PilotSysAVCamrFLSFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d40f707b274384896b64c067976bcf8">
                      <SHORT-NAME>PilotSysAVCamrFRSFltSts_PilotSysAVCamrFRSFltSts_PilotSysAVCamrFRSFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8da840ce70e03796aa3aba2bb8798b8a">
                      <SHORT-NAME>PilotSysAVCamrRFltSts_PilotSysAVCamrRFltSts_PilotSysAVCamrRFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="651e8178d44a3ec2a37d612d06ae0afa">
                      <SHORT-NAME>PilotSysAVCamrRLSFltSts_PilotSysAVCamrRLSFltSts_PilotSysAVCamrRLSFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="95e15351823f37ec80f2b5500c2bde0c">
                      <SHORT-NAME>PilotSysAVCamrRRSFltSts_PilotSysAVCamrRRSFltSts_PilotSysAVCamrRRSFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f661a4b498c33d56bc3f2aef99a6d682">
                      <SHORT-NAME>PilotSysFDRFltSts_PilotSysFDRFltSts_PilotSysFDRFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="86a589b7fedb3b938f442bc93333252e">
                      <SHORT-NAME>PilotSysFLIDARFltSts_PilotSysFLIDARFltSts_PilotSysFLIDARFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e77cc24e09c132aa88c33138861ea7fc">
                      <SHORT-NAME>PilotSysHDAVMCamrFFltSts_PilotSysHDAVMCamrFFltSts_PilotSysHDAVMCamrFFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="653d6838595530cc91a444089a1064e7">
                      <SHORT-NAME>PilotSysHDAVMCamrLHFltSts_PilotSysHDAVMCamrLHFltSts_PilotSysHDAVMCamrLHFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f52155882b883428ab66a97dbf6cee86">
                      <SHORT-NAME>PilotSysHDAVMCamrRFltSts_PilotSysHDAVMCamrRFltSts_PilotSysHDAVMCamrRFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52d3236d84373efc80abc0d35e00cec2">
                      <SHORT-NAME>PilotSysHDAVMCamrRHFltSts_PilotSysHDAVMCamrRHFltSts_PilotSysHDAVMCamrRHFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2283fccdf7b3fbfac88e05e1f79432a">
                      <SHORT-NAME>PilotSysLFSDAFltSts_PilotSysLFSDAFltSts_PilotSysLFSDAFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d538db4e6983b349b745a3d6cea32d1">
                      <SHORT-NAME>PilotSysLHRDAFltSts_PilotSysLHRDAFltSts_PilotSysLHRDAFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c4a76049fd7b33faa5ceba934915fb2b">
                      <SHORT-NAME>PilotSysMsg_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb09c393876336da87a8287892c1635b">
                      <SHORT-NAME>PilotSysRFSDAFltSts_PilotSysRFSDAFltSts_PilotSysRFSDAFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be2e671757fe3090b2483a7862259ac9">
                      <SHORT-NAME>PilotSysRHRDAFltSts_PilotSysRHRDAFltSts_PilotSysRHRDAFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9add0482d6d032ddbc2b5c0e64bbcba2">
                      <SHORT-NAME>PilotSysUSSFltSts_PilotSysUSSFltSts_PilotSysUSSFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9f09ea4c7d031d4a96e13f55d973554">
                      <SHORT-NAME>PilotTkovMsgReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ea3a1f6bd4930a1b4b6c87f704f4c42">
                      <SHORT-NAME>PitchRTK_IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6029d0b388b73bd99b63799e0462901c">
                      <SHORT-NAME>PitchSigma_IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38ac70de75d83c5ba597e9dfbaf813e3">
                      <SHORT-NAME>PosALCFailed_PosALCFailed_PosALCFailed_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0358eb50da4331ca717981d0c910e1f">
                      <SHORT-NAME>PositionAttitudeStatus_PositionAttitudeStatus_PositionAttitudeStatus_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9709723474573803adb40f8033e743bd">
                      <SHORT-NAME>PriySSBAV_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c0503cc752637c08362249c3945ab8e">
                      <SHORT-NAME>PriySSBA_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20d8364cdc8d3bed97e0c49508c50435">
                      <SHORT-NAME>PrkgDstCtrlSwResp_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cfd9e9d55c7e36238daf02cc38e22a7f">
                      <SHORT-NAME>PwrLftgtClsSwtActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a11a00da60e73da1b2405c0ca343bf45">
                      <SHORT-NAME>PwrMdCtrlResp_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49c04d79b2a132ab8e12a3f5e4bd808a">
                      <SHORT-NAME>PwrMdExtrCtrlAvlbl_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fe15afa6c9883644be46dd3e0dd20384">
                      <SHORT-NAME>PwrMdMstrAccryA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f865aa51df84342aa4fc79e6ccf1d96f">
                      <SHORT-NAME>PwrMdMstrRunCrkA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b244d22994233c99df742bac818bcb4">
                      <SHORT-NAME>RAAlrWorDis_RAAlrWorDis_RAAlrWorDis_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f2ddaa7c4303d6d909944394d4d8eef">
                      <SHORT-NAME>RACtlReq_RACtlReq_RACtlReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fa4a0dce402230b784dd6734affc3d98">
                      <SHORT-NAME>RADSSwSts_RADSSwSts_RADSSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c7a6b9a242633078b91531920e2c32b6">
                      <SHORT-NAME>RASysSts_RASysSts_RASysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8bd2787467f037f88bba8a532f469caf">
                      <SHORT-NAME>RBSDAndLCAWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84181d4642373ccf94904a0c3967a409">
                      <SHORT-NAME>RCTSysSelReq_RCTSysSelReq_RCTSysSelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7cc1cd50f0b33e9c8eeb9c4142d34d32">
                      <SHORT-NAME>RCTSysSelSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1af06b0bc17e3b33bbb5dbd2b2a1db20">
                      <SHORT-NAME>RCWSelReq_RCWSelReq_RCWSelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b730cca1d79137fa9b74ba0a6cdfde2a">
                      <SHORT-NAME>RDASwReq_RDASwReq_RDASwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e6e4dd3a3a83c89ad37c834163904af">
                      <SHORT-NAME>RDASwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ae66981704f3b58aa9e63a2a3803559">
                      <SHORT-NAME>RDASysSta_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bb22948d4d9433b79361b5c1c70062d6">
                      <SHORT-NAME>RDOWWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20619f8cdea43de68b936db5e9513a84">
                      <SHORT-NAME>RDayTimeRunningLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02b535014464340f9c866cdd7d30dc52">
                      <SHORT-NAME>RFCTWrnng_ADAS_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="232e4ccb82e6311a87ae81eea021ef2c">
                      <SHORT-NAME>RFCTWrnng_RFCTWrnng_RFCTWrnng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="3d54eec2739f3e928941ae75f0869380">
                      <SHORT-NAME>RFSDA_100ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="728056f97116343590761984b4377657">
                      <SHORT-NAME>RFSDA_20ms_Group02_CRC_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d032f41db55b3ec0a9267590ae1c8f16">
                      <SHORT-NAME>RFSDA_20ms_Group02_RC_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="58c505ccca6e36ca89cca0e71d70606f">
                      <SHORT-NAME>RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="105678982b8239b492b824ab5b9401e9">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="11457f76f4a2331c992b493e11daf044">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d5fd85df5db632d494465ffb0ff4fe0d">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a2f65438cfd39fd8c746e56468cf711">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77e90bfe7f4437fb8e9e9624faef07ee">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f03c54a68dc39d5b13b3cb1f30023e7">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ee2080f249b3d47a001b0b53ccca79d">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b1e45ce5c1434838eb7eaea50bf27e5">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e62cb97f9ed631dea82d999bb83de9a3">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51c9cb75909f356c8f0af25c6c220edf">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75b951c4c1ae3da1a997bd50a77f5b0e">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6cd1ab300e23e038fb253a3298939d0">
                      <SHORT-NAME>RFSDA_20ms_Group02_Reserved9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="183256a23f4530ca9a99ca2ad4ae6338">
                      <SHORT-NAME>RFSDA_20ms_PDU02_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="b61c1f80a0583ff0a872d0caa9cd514b">
                      <SHORT-NAME>RFSDA_BKPCANFD_100ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="060cd3c12af138ef880b922f69506495">
                      <SHORT-NAME>RFSDA_BKPCANFD_20ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b337442039c23719b88a8cd1519015eb">
                      <SHORT-NAME>RFSDA_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="4bcec0dafe6934a8895d0b6a9a478b1b">
                      <SHORT-NAME>RHRDA_50ms_Group04_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e860e8017f653200a563b73ca807106f">
                      <SHORT-NAME>RHRDA_50ms_Group04_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf00d44c8fc132b8a681b2bb9b5dfc7f">
                      <SHORT-NAME>RHRDA_50ms_Group04_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e06575a3ac86377f9fb940e67f18e61a">
                      <SHORT-NAME>RHRDA_50ms_Group04_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c66f6bf3e4b341ba8ef7f574188caf3">
                      <SHORT-NAME>RHRDA_50ms_Group04_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f33036ab41e43302be8cfee9fb1290c3">
                      <SHORT-NAME>RHRDA_50ms_Group04_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b85e9cfd18d3386bac0d1a9548e56acf">
                      <SHORT-NAME>RHRDA_50ms_Group04_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="6549c1aa6cb13fa1bd45cc33b0e1a6a9">
                      <SHORT-NAME>RHRDA_50ms_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="2278e9e8d0833d199298a9094e94bc29">
                      <SHORT-NAME>RHRDA_BKPCANFD_50ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="19645d195d96353b8c30c21f7e39c475">
                      <SHORT-NAME>RHRDA_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="e1a86172fad933fbbb69ac3f06d33018">
                      <SHORT-NAME>RHZCUAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f71a5a1cc7338e795fa753d6acaf763">
                      <SHORT-NAME>RHZCU_100ms_Group10_CRC_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97be1b0056683712a7c38a18c1972ac5">
                      <SHORT-NAME>RHZCU_100ms_Group10_RC_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47b0944858013a7baf825c2fe0c9ca80">
                      <SHORT-NAME>RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8fa4a9576f9d3fe3bd41f84a392ad449">
                      <SHORT-NAME>RHZCU_100ms_Group10_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bac0c494f84c397db304823c17e47ab4">
                      <SHORT-NAME>RHZCU_100ms_Group10_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6566034c69d37f5904aa8eacb535e94">
                      <SHORT-NAME>RHZCU_100ms_Group10_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5eb484e1fef359d8b7bbe405d38a456">
                      <SHORT-NAME>RHZCU_100ms_Group10_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="447645786d02339eb9886cdda5c69f62">
                      <SHORT-NAME>RHZCU_100ms_PDU06_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cfc51f69173031ddbd8ce4ea369fedf7">
                      <SHORT-NAME>RHZCU_100ms_PDU10_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="17907dc51a0a3afa8ece1e06df922100">
                      <SHORT-NAME>RHZCU_100ms_PDU15_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="7962317f56bd3c85b99867759678cce2">
                      <SHORT-NAME>RHZCU_100ms_PDU20_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="84dbc4f855d83bb583618bb5dfa0db01">
                      <SHORT-NAME>RHZCU_50ms_Group01_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8756df148ea93d96846f287f4b346485">
                      <SHORT-NAME>RHZCU_50ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="82a37d9c8f74394c92a6bc3fa41e02ab">
                      <SHORT-NAME>RHZCU_50ms_Group01_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="28afc26817983c818a9b535aa0d35265">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="56553b7a40743c798c8ff8d0989340e2">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e26f03f80e7a32ccb2b06326db2c7ae8">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6379f4620a20389982ffff1a7ec42033">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0af991a8acb43ee5bedc9f0328972a07">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55c3004734ec39fc9e13c785e154b015">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8b35161fc403dcaa383a1f9315908cb">
                      <SHORT-NAME>RHZCU_50ms_Group01_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="405fbe8372e33a23b273269177d138f2">
                      <SHORT-NAME>RHZCU_50ms_Group27_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2f9bd5eba9c93c80ab61b493741a5233">
                      <SHORT-NAME>RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4aa1cd5e5685304282c79bbbbd78c6b5">
                      <SHORT-NAME>RHZCU_50ms_Group27_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="813ade53e05d3555b050121e436cfabe">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba71e3a25b7737ccb467ceefe8591fa4">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="743de6c7dbe034e08a41d2af07ba365b">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d401c0ba347432a2a67bb4bc66c58f3a">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a9280bb172338438445e0b9999b8837">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0ed31fc8995732fcaedf8a9dbb5f7c2c">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c163ef5580db31228927ad9a7402db81">
                      <SHORT-NAME>RHZCU_50ms_Group27_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="45370ea49adc3a049d6a1eaa248ca1bb">
                      <SHORT-NAME>RHZCU_50ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1cd248e980873efb8aad2aa12ca9112a">
                      <SHORT-NAME>RHZCU_50ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a25789d1509131bcb0dd17023d9aad12">
                      <SHORT-NAME>RHZCU_50ms_PDU27_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="404fc441eded32f38207e0bf08b0ef7d">
                      <SHORT-NAME>RHZCU_BDCAN_100ms_FrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="15e4cc9186763ceca11586051faf6c1f">
                      <SHORT-NAME>RHZCU_BKBCANFD_50ms_FrP27_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="11b36d372da4333a9a87b7a21de26940">
                      <SHORT-NAME>RHZCU_ICBVC_50ms_PDU14_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="70d5d67a10993eeab05badd735d67b7b">
                      <SHORT-NAME>RHZCU_ICBVC_LHBKBCANFD_50ms_FrP14_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="fccf72d21273300a958910956855242b">
                      <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP10_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d159251971703dbeaa06adf15be26d80">
                      <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP15_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="52f5c5aeb41431ae989dd13314d2fa18">
                      <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP20_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="cfb14769071935a8808c53f21a559c75">
                      <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f363029a40e5339aad6b91aa83ccd580">
                      <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="17990ba551683d2bac5e1524d4e237dc">
                      <SHORT-NAME>RHZCUeFs1Sts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22aeb2c2a06a36858b6841fb341325de">
                      <SHORT-NAME>RHZCUeSw33DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b435d87c67633b69bd2ffccb6fcda649">
                      <SHORT-NAME>RHZCUeSw33Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41f145bcbd8a37e497ad281660386163">
                      <SHORT-NAME>RHZCUeSw37DiagSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2865fcb76851344e9e61e99c6b003b8e">
                      <SHORT-NAME>RHZCUeSw37Sts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66b2032e035c33068e12fa40a7df37c6">
                      <SHORT-NAME>RHZCUeSw3DiagSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d02c83cc9d093d41ae9cdfc8f0829917">
                      <SHORT-NAME>RHZCUeSw3Sts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff47df3f08ed3e4ab8df90dea3021968">
                      <SHORT-NAME>RHZCUeSw41DiagSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c69b0c9b1213e61b6b50e277610f95a">
                      <SHORT-NAME>RHZCUeSw41Sts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4a36120fce64347aa9a2f424eaf3cb5d">
                      <SHORT-NAME>RHZCUeSw42DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ad7851eb56d13e21a40037bcc8d3c770">
                      <SHORT-NAME>RHZCUeSw42Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c8c476bd4063b998ee6618f8d6388ea">
                      <SHORT-NAME>RHZCUeSw43DiagSts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="698ae0ae80c331ddb81010a9ae6e4471">
                      <SHORT-NAME>RHZCUeSw43Sts_RHZCU_50ms_Group27_RHZCU_50ms_Group27_RHZCU_50ms_Group27_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3744632be46638f68521d358dae25539">
                      <SHORT-NAME>RHZCUeSw9DiagSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4335648576a139b9a7e09f93e8af93bc">
                      <SHORT-NAME>RHZCUeSw9Sts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3b3f7fd083d038b3935a01f2e97a8601">
                      <SHORT-NAME>RLDircnLghtCtrl_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="042f495c3c41348aa40967f95e788bfc">
                      <SHORT-NAME>RLDircnLghtFltsts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="609ff421d3c23d3fbd48f2a1f99a3321">
                      <SHORT-NAME>RLDircnLghtFltsts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f30605f789b33c78a4926d9949eb6a5f">
                      <SHORT-NAME>RLDircnLghtSts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68b80d43bd013ea8a076117e1234d5c3">
                      <SHORT-NAME>RLDircnLghtSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91c8958da04d339b992407ea1565f2b1">
                      <SHORT-NAME>RLDoorOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68d73e98cce73843b1902d39f7ff8b41">
                      <SHORT-NAME>RLObsRng_RLObsRng_RLObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f05e85a0148b37859398ad312a8f234f">
                      <SHORT-NAME>RLRdrEmgcLineChngWrnng_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d7ccac475a293e01bca92218f4b33d7f">
                      <SHORT-NAME>RLSInitnFltPrst_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9fec24a4acc37b188c2f86a28764c4a">
                      <SHORT-NAME>RLSObsRng_RLSObsRng_RLSObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89d66352f7b23840b87490b2910fdf04">
                      <SHORT-NAME>RLSUSSSts_RLSUSSSts_RLSUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e25df1258733f6bad62d014d2c5c712">
                      <SHORT-NAME>RLSideLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b5e0ff9d25f3090a3b553c27b1a46f2">
                      <SHORT-NAME>RLSideObsRng_RLSideObsRng_RLSideObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="44f828ba98f73993b206a628c61774cb">
                      <SHORT-NAME>RLTirePrsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c4a03e34ee043160946999d7356b1f1f">
                      <SHORT-NAME>RLTirePrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d6c8422f9363929b0bd5d4b93525807">
                      <SHORT-NAME>RLTireSts_RLTireSts_RLTireSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52e85f6f65553cc289def5d4ab75242e">
                      <SHORT-NAME>RLTireTemV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="464bbcea9974396d896e29c71f26a005">
                      <SHORT-NAME>RLTireTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0bb2a850d05b39b5b29273c8f5b0c2aa">
                      <SHORT-NAME>RLUSSSts_RLUSSSts_RLUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ccafa993361c3dd89fe3ed5f3f9852f3">
                      <SHORT-NAME>RMLUSSSts_RMLUSSSts_RMLUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="756b2cd32fa33c00a6c6c58cde5f6a73">
                      <SHORT-NAME>RMRUSSSts_RMRUSSSts_RMRUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5e6eafa1b36e3a4d9dcfdeda959f8e98">
                      <SHORT-NAME>RMainBeamLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d83a60103153eb0b2378d8f81e16512">
                      <SHORT-NAME>RRCTAWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="928480b0ec513873a952900f73db7d6b">
                      <SHORT-NAME>RRDircnLghtCtrl_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2edebfc7546e3e528dbb72e6bf6022c9">
                      <SHORT-NAME>RRDircnLghtFltsts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e891a8a2d06a336ba67483803cc8cf61">
                      <SHORT-NAME>RRDircnLghtFltsts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d723a8e0060a335bb3abc81954ce490d">
                      <SHORT-NAME>RRDircnLghtSts_HW_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2e929bd68843cabbe279d1eb2f951e9">
                      <SHORT-NAME>RRDircnLghtSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="23feb3c54f6c3c3e8bdba0c96ce3e4cc">
                      <SHORT-NAME>RRDoorOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e09c5f83eb6132b986a9d6c51c797a89">
                      <SHORT-NAME>RRObsRng_RRObsRng_RRObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="565c61d6f24938e19daef1f53b53a837">
                      <SHORT-NAME>RRRdrEmgcLineChngWrnng_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dfec031c99463fb8be50bb77db3947ce">
                      <SHORT-NAME>RRSObsRng_RRSObsRng_RRSObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="98e98560f3d433968a3ea53f61224ecc">
                      <SHORT-NAME>RRSUSSSts_RRSUSSSts_RRSUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="beacea11a6da3152a3609482227c897a">
                      <SHORT-NAME>RRSideLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="476ebb987a1e324f8966ba252d125af5">
                      <SHORT-NAME>RRSideObsRng_RRSideObsRng_RRSideObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ded93408bd73c20bb25278a3798cc90">
                      <SHORT-NAME>RRTirePrsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ddbfea255c9f387f8dc82a7675fc8e63">
                      <SHORT-NAME>RRTirePrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19dbd664ffe83b9ea91d0e6898835287">
                      <SHORT-NAME>RRTireSts_RRTireSts_RRTireSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cedb338655e832cdab347270de3346dc">
                      <SHORT-NAME>RRTireTemV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a071f165bb1a38f9becc4313e16c0ab3">
                      <SHORT-NAME>RRTireTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5dda1d1dbfc532059942d768876b37cd">
                      <SHORT-NAME>RRUSSSts_RRUSSSts_RRUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38480f92e6443a029d759f2423a8487b">
                      <SHORT-NAME>RZCU_50ms_Group37_CRC_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ec927c9e9223edd84444ddad9731d39">
                      <SHORT-NAME>RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="08de0f68acb0328ba0cc3eba2a3d5660">
                      <SHORT-NAME>RZCU_50ms_Group37_RC_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12c67526b55b3fb6b4903698df07ab34">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="40deae14fe9d3e53929c7cda8682a190">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved23_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d3d6b534c89c32d2aa8d8325d049d732">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved31_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f132b0d672537b8a0b54e3edf1ddba7">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved34_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0804113291193007b373cda065e9cd52">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved36_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52bb7e76bd133b09ba8a770db67d34ba">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved38_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b12e24447d034e8bde365834dacedb1">
                      <SHORT-NAME>RZCU_50ms_Group37_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4739a8c503d73f0dbddd4ba96c35f004">
                      <SHORT-NAME>RZCU_50ms_PDU37_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="9142b8739a2e3369818cc92b15cba998">
                      <SHORT-NAME>RZCU_BKBCANFDAvlbly_RZCU_BKBCANFDAvlbly_RZCU_BKBCANFDAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="a39b4527da1e373c8dc87a9b4376f9f5">
                      <SHORT-NAME>RZCU_LHBKBCANFD_50ms_FrP37_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="b3fa05ae7ca532c8a10a53322ec283aa">
                      <SHORT-NAME>RearFogLghtFltsts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f9a9ee70ebb348db9af8b65a8f5ec8e">
                      <SHORT-NAME>RearFogLghtSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b130034c72239d485d39ce833a54c3d">
                      <SHORT-NAME>ResetCnt_ResetCnt_ResetCnt_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab606fc757203986adec1134e1bf0b81">
                      <SHORT-NAME>RevsLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bdfa461392f93358a31e5dbf306814f2">
                      <SHORT-NAME>RevsLghtFltSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a7e14225e6c38c6a9093baa44821576">
                      <SHORT-NAME>RevsLghtSts_RZCU_50ms_Group37_RZCU_50ms_Group37_RZCU_50ms_Group37_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75fb285416433191b6d846e1e237c984">
                      <SHORT-NAME>RightEyeOccludeStatus_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="819e77ac83503b37974032076d456cee">
                      <SHORT-NAME>RmtDrvrTrgtEPSStrgWhlAng_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="36a97d87fe9632f7a39f7b6dbef12fe5">
                      <SHORT-NAME>RmtParkngAstAbotBtnSts_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a485cb74c7a3b6cb491e75add0fee7e">
                      <SHORT-NAME>RmtParkngAstBtnSts_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6cab301bce1c33d9b44bb381f085532e">
                      <SHORT-NAME>RmtParkngAstDvcFlrRsn_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7335e1fd07b35c59b39bc3b0e8f89bc">
                      <SHORT-NAME>RmtParkngAstDvcSts_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b827e3940463b44a0b154f4f240acb7">
                      <SHORT-NAME>RmtParkngAstParkngOutDircnSeln_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9d0256d5f3b396e971cf2f21311a740">
                      <SHORT-NAME>RrCrnRdrCalSts_RHRDA_50ms_Group04_RHRDA_50ms_Group04_RHRDA_50ms_Group04_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1920222cbca63afea7759c2b200a3751">
                      <SHORT-NAME>RrFogLightOnReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db31ad4c66f7360487543bd51365c9d6">
                      <SHORT-NAME>RrMidLObsRng_RrMidLObsRng_RrMidLObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="935526c504a13b7cb6ad19cacbac8cff">
                      <SHORT-NAME>RrMidRObsRng_RrMidRObsRng_RrMidRObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f4fe4f5250c3cacb1f25d19572b5bc9">
                      <SHORT-NAME>RrObsDist_RrObsDist_RrObsDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55295e597aa93003b973d78c690d7b16">
                      <SHORT-NAME>RrPDCAudWrnng_RrPDCAudWrnng_RrPDCAudWrnng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea7903e1f4b539698a86c96d6a28b088">
                      <SHORT-NAME>RrTireStdPrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="daf7b5e5eacb3316b395f2a2bb56ef02">
                      <SHORT-NAME>RstrFctryDeftsReq_RstrFctryDeftsReq_RstrFctryDeftsReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b36082e7b283e4095ce3ff9c6106cf8">
                      <SHORT-NAME>SCUAPAUnderCtrlActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c2482017a8f03429ad92800856966b33">
                      <SHORT-NAME>SCUActrMvmntSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1293eb5df70830139717aa859002e09d">
                      <SHORT-NAME>SCUDrvMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d3d8532d06fa3e37851760af9ec3aa0c">
                      <SHORT-NAME>SCUDrvnIntrvnPos_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e569a444f3cd30e781ad9e138a2bfea1">
                      <SHORT-NAME>SCUDrvrIntrvnActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5e57b25eec3737369b01808c7bca07f0">
                      <SHORT-NAME>SCUExtdShifterActrPos_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b596d9b29d26391b8db58c0704a96761">
                      <SHORT-NAME>SCUExtdShiftrFlr_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef1c3d22d89d3e5a9db6f09dc016d39f">
                      <SHORT-NAME>SCUFltLvlWarn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="592beb85dc313f19ad381998ee1a07fa">
                      <SHORT-NAME>SCUParkActrSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a2ff2140abd239e0a7eb491482373113">
                      <SHORT-NAME>SCUParkLckReqEPMCU_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6b2219c6b0e13d3390f50701d1131e20">
                      <SHORT-NAME>SCUParkLckReqVEPMCU_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0a941b17cab3af1bb0de56a5c168739">
                      <SHORT-NAME>SCUParkLckReqV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="865c969c029c37c79b08559fffa3a75a">
                      <SHORT-NAME>SCUParkLckReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f0c79bec9fe38dc80d90f503a38e4bc">
                      <SHORT-NAME>SCUShftLvrPosIncnstntFlag_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8041d8b1371b3496922673fe55f7993e">
                      <SHORT-NAME>SCUShftLvrPosTrgt_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a8824058e9336edb64a0ad26b1f5dc8">
                      <SHORT-NAME>SCUShiftrLvrPosnLtchActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13550333c043334892892cca7cfc680d">
                      <SHORT-NAME>SCUShiftrLvrPosn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c37e7155886b314c96cb8d8df4ac7788">
                      <SHORT-NAME>SCUShiftrLvrRawPosn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="593c7fa485df373fbccef64ffb1adf1e">
                      <SHORT-NAME>SCUShiftrOpngRmndr_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ffaa3abf54eb3d4087892941b88af57a">
                      <SHORT-NAME>SCUShiftrPosnInvsn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="92e36b7f1a5a304a8a3cc328ebaa8660">
                      <SHORT-NAME>SCUTapUpDwnSwStaInvsn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d83a3a452ed3f398d88f08f437f0085">
                      <SHORT-NAME>SCUTapUpDwnSwSta_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66275df255f2315c9779548a5a998af3">
                      <SHORT-NAME>SDMAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b5442819dbf39f998c2aa588f2e1a2d">
                      <SHORT-NAME>SDWLSFObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69c9669aa9df3a95bf31c9c9a1d1f6e5">
                      <SHORT-NAME>SDWLSRObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="95d30d85a05e3a5f882d4796c0ff273a">
                      <SHORT-NAME>SDWRSFObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8d05624008e3cf5bbeeeb6a9687bc32">
                      <SHORT-NAME>SDWRSRObsRng_IPD_50ms_Group14_IPD_50ms_Group14_IPD_50ms_Group14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7cc7676c2c139b48a02d39a6025b392">
                      <SHORT-NAME>SLIFAudWrnng_IPD_SLIFAudWrnng_IPD_SLIFAudWrnng_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd3f71371cbc32519d68861318c2fd56">
                      <SHORT-NAME>SLIFSts_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6523425d97f634528d2fc4e90eb49ae3">
                      <SHORT-NAME>SLIFSysFltSts_SLIFSysFltSts_SLIFSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="227d103faf43342fa9b24d7c5ec661a3">
                      <SHORT-NAME>SLIFUpdtIndReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ed63c3a68e0372e8e46b81752fdf7bc">
                      <SHORT-NAME>SLIFUpdtIndResp_IPD_SLIFUpdtIndResp_IPD_SLIFUpdtIndResp_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2259ec123b3737bfbc432d5893f13fd1">
                      <SHORT-NAME>SLIFUpdtInd_IPD_SLIFUpdtInd_IPD_SLIFUpdtInd_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0753d3991402323e906612a466cb3c11">
                      <SHORT-NAME>SLIFWrnngMdReq_SLIFWrnngMdReq_SLIFWrnngMdReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eab706516df43e3da1d122389907d79b">
                      <SHORT-NAME>SLIFWrnngMdResp_SLIFWrnngMdResp_SLIFWrnngMdResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4993709e233138158f890ad481fa01ff">
                      <SHORT-NAME>SSBTrigd_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ffdbfb79efd38e8b7b10ace4a419ec5">
                      <SHORT-NAME>SWSCnfmSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="35e24f65e74b397ba40d206c2fbe9f68">
                      <SHORT-NAME>SWSSelDwnSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2cc2f6e32f3326c90c9fab5d61f6700">
                      <SHORT-NAME>SWSSelLSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3709e55769633b24b4012f7d30a4d9d6">
                      <SHORT-NAME>SWSSelRSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4edecbd4a175319eb019672a7c69a8ed">
                      <SHORT-NAME>SWSSelUpSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="175e2ff6c36f3ee3bdaf9f392e6e75e0">
                      <SHORT-NAME>SatAz10_SatAz10_SatAz10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd01d836a5843c0e849d6c5babaf9208">
                      <SHORT-NAME>SatAz11_SatAz11_SatAz11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66043ab85e0e31028ef8ded5f8ae8510">
                      <SHORT-NAME>SatAz12_SatAz12_SatAz12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a121e2b0d5b93e4b8a02e8a2bb1b09df">
                      <SHORT-NAME>SatAz13_SatAz13_SatAz13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f7243c9f91b4387e8e51e9e74b8d8efc">
                      <SHORT-NAME>SatAz14_SatAz14_SatAz14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7222e65230113644972ca6c37723240c">
                      <SHORT-NAME>SatAz15_SatAz15_SatAz15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4bbfe4f2dd636ba8ccf5ac53c0962f4">
                      <SHORT-NAME>SatAz16_SatAz16_SatAz16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c362daeef842337a97bb13d92c34442a">
                      <SHORT-NAME>SatAz17_SatAz17_SatAz17_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02430f838bf9376bb4b8ae7bce849102">
                      <SHORT-NAME>SatAz18_SatAz18_SatAz18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="14c842a2e96d35848c96a025de57056d">
                      <SHORT-NAME>SatAz19_SatAz19_SatAz19_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b0cf0b11290f3c7db40c1dd3e98f51b4">
                      <SHORT-NAME>SatAz1_SatAz1_SatAz1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b0876693c8a33d39afc32f9c6c513bf9">
                      <SHORT-NAME>SatAz20_SatAz20_SatAz20_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c70a17dd7e3e370b943bbd3206cd3f43">
                      <SHORT-NAME>SatAz2_SatAz2_SatAz2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4cc290bd02863ef5b41f8adcd99befc3">
                      <SHORT-NAME>SatAz3_SatAz3_SatAz3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7be965570e6539219ef7859d50ed27e5">
                      <SHORT-NAME>SatAz4_SatAz4_SatAz4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4bd538359e93426bb0f11f786cd09fe">
                      <SHORT-NAME>SatAz5_SatAz5_SatAz5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bb6fa7d68d28357db8dc23bda0f8db5a">
                      <SHORT-NAME>SatAz6_SatAz6_SatAz6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e464d91b9613c6b9b99767a02be0eab">
                      <SHORT-NAME>SatAz7_SatAz7_SatAz7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d020ed09487d339d8ff99b992dc586bc">
                      <SHORT-NAME>SatAz8_SatAz8_SatAz8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b19f7275cbd3f9fbd98a47c1c49ca19">
                      <SHORT-NAME>SatAz9_SatAz9_SatAz9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7124ae6449e3f70814b9ade1adad5d6">
                      <SHORT-NAME>SatCNO10_SatCNO10_SatCNO10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be8a4543b7d4348d9a9bc71ef1b7796a">
                      <SHORT-NAME>SatCNO11_SatCNO11_SatCNO11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ca004ffffdd3233a8feaa743550472b">
                      <SHORT-NAME>SatCNO12_SatCNO12_SatCNO12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f93184fad503386389b9426dd9eaab3f">
                      <SHORT-NAME>SatCNO13_SatCNO13_SatCNO13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="63ada37a55643975acfe8cde8565b98e">
                      <SHORT-NAME>SatCNO14_SatCNO14_SatCNO14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9b0feb7d2db03bffaa21272e2269273f">
                      <SHORT-NAME>SatCNO15_SatCNO15_SatCNO15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="03db723b43293b81b36406513c643f08">
                      <SHORT-NAME>SatCNO16_SatCNO16_SatCNO16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9778e0f423ca3a9087d9ea4abea03e2d">
                      <SHORT-NAME>SatCNO17_SatCNO17_SatCNO17_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bb898fe71aa3dfd9ee13c9b321b98ee">
                      <SHORT-NAME>SatCNO18_SatCNO18_SatCNO18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dca01196a56533f498c64c1afe0863e2">
                      <SHORT-NAME>SatCNO19_SatCNO19_SatCNO19_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5cc318474d5c3bcf883e4e6461803263">
                      <SHORT-NAME>SatCNO1_SatCNO1_SatCNO1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fba1d15dce6351c9f8400c137219ab7">
                      <SHORT-NAME>SatCNO20_SatCNO20_SatCNO20_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a8f21fbe0433691ac9cb802ce6aba5e">
                      <SHORT-NAME>SatCNO2_SatCNO2_SatCNO2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ade30b66547e3789ba6ae92c94d85586">
                      <SHORT-NAME>SatCNO3_SatCNO3_SatCNO3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84a0c28ad90935c882158cc6aecf92f3">
                      <SHORT-NAME>SatCNO4_SatCNO4_SatCNO4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="903c2a0027ae3f9a8739999ca223f543">
                      <SHORT-NAME>SatCNO5_SatCNO5_SatCNO5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dfafd7f557063541af682ab793b83d41">
                      <SHORT-NAME>SatCNO6_SatCNO6_SatCNO6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be5a64f2103f3675bad7a17b5193ae31">
                      <SHORT-NAME>SatCNO7_SatCNO7_SatCNO7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cf005a1988433c88bb5a80a4469aab26">
                      <SHORT-NAME>SatCNO8_SatCNO8_SatCNO8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fe1c437452343b0aa9f4f3ef06466191">
                      <SHORT-NAME>SatCNO9_SatCNO9_SatCNO9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1900a71caff131d8aa5aee378cabba38">
                      <SHORT-NAME>SatElv10_SatElv10_SatElv10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0c3e9c0f4ff3580b6852d21097f797a">
                      <SHORT-NAME>SatElv11_SatElv11_SatElv11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a1399e29b0cb322fb655a2eab832dbd9">
                      <SHORT-NAME>SatElv12_SatElv12_SatElv12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="009af2e5a5d03c8ab29bb8fbd2f60cbe">
                      <SHORT-NAME>SatElv13_SatElv13_SatElv13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9a60f7dbb803b7284c7210d6586a95e">
                      <SHORT-NAME>SatElv14_SatElv14_SatElv14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="742b2b5936893af9b1924043c11331f1">
                      <SHORT-NAME>SatElv15_SatElv15_SatElv15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7dd34f813a193ed78b9f14f4b1765fe8">
                      <SHORT-NAME>SatElv16_SatElv16_SatElv16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fba5828e7cf534d18c00efbca0e2b9d7">
                      <SHORT-NAME>SatElv17_SatElv17_SatElv17_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c5819f447f03acd8ff389bde2603c4b">
                      <SHORT-NAME>SatElv18_SatElv18_SatElv18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3487455292223e9abe2bdad7e0725224">
                      <SHORT-NAME>SatElv19_SatElv19_SatElv19_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c8807e664643e9b88a73a93cca18ff7">
                      <SHORT-NAME>SatElv1_SatElv1_SatElv1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12dc20d53f003bb6a8b6f3b2bb6c8b2c">
                      <SHORT-NAME>SatElv20_SatElv20_SatElv20_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d1a47f441363225ac9e01bf207d70ad">
                      <SHORT-NAME>SatElv2_SatElv2_SatElv2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb27a45e8fe23297ae07a367d7ec1ff0">
                      <SHORT-NAME>SatElv3_SatElv3_SatElv3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3bca40f9abee325181a614a05dc1f2fd">
                      <SHORT-NAME>SatElv4_SatElv4_SatElv4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="295dedf8db7d385596f495cd76c7447e">
                      <SHORT-NAME>SatElv5_SatElv5_SatElv5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="327ce0d0b75a354ea505f5f80b9a5895">
                      <SHORT-NAME>SatElv6_SatElv6_SatElv6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4db52f9743883981b40c0ae4e6816ece">
                      <SHORT-NAME>SatElv7_SatElv7_SatElv7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c66cc4b56ceb3cc9930149e69cdfd0d7">
                      <SHORT-NAME>SatElv8_SatElv8_SatElv8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="607d492d778e3581a644ca98bb9cff80">
                      <SHORT-NAME>SatElv9_SatElv9_SatElv9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c7b35c9f3bb03b038380fef5a553c009">
                      <SHORT-NAME>SatID10_SatID10_SatID10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="756a25abf3ae3eedb479a0530cf7d976">
                      <SHORT-NAME>SatID11_SatID11_SatID11_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6aedaeb8f73037dd8570f74f59e6f247">
                      <SHORT-NAME>SatID12_SatID12_SatID12_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="527d6911c3a03e37949d3c43b12d6d5e">
                      <SHORT-NAME>SatID13_SatID13_SatID13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0cca6892749234a4bbe4ee61e3db135e">
                      <SHORT-NAME>SatID14_SatID14_SatID14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cba868ad7013333cb542540bb0719576">
                      <SHORT-NAME>SatID15_SatID15_SatID15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c92be279e1443171a519251a1429a5ee">
                      <SHORT-NAME>SatID16_SatID16_SatID16_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be1701e1e212305a802e9802a1b14753">
                      <SHORT-NAME>SatID17_SatID17_SatID17_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9676540a7a13663952c0dea35084b5b">
                      <SHORT-NAME>SatID18_SatID18_SatID18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45fd538866c232a1b401df3e0cd40cdf">
                      <SHORT-NAME>SatID19_SatID19_SatID19_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="056acf943bde33e6ae63697fbe1c93f6">
                      <SHORT-NAME>SatID1_SatID1_SatID1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="406bf3a06b75359392c16aa1754a8440">
                      <SHORT-NAME>SatID20_SatID20_SatID20_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be5f3fdb1ee831f78c038b254df3b856">
                      <SHORT-NAME>SatID2_SatID2_SatID2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b49f334028832dda0883d2bbfe0cd50">
                      <SHORT-NAME>SatID3_SatID3_SatID3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="67ad914ca2ad30d3a510fd70fb88976e">
                      <SHORT-NAME>SatID4_SatID4_SatID4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8a412a4e8863903b40f3d70b91596d8">
                      <SHORT-NAME>SatID5_SatID5_SatID5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f0e5d316d4a5346480a011ce4e11984c">
                      <SHORT-NAME>SatID6_SatID6_SatID6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="071ab1985b2736cea4d81cd3e32764af">
                      <SHORT-NAME>SatID7_SatID7_SatID7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3277c419d8f33d2fa56b66376e39b67b">
                      <SHORT-NAME>SatID8_SatID8_SatID8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47acbe1e3d0738dc832da7f1e2920976">
                      <SHORT-NAME>SatID9_SatID9_SatID9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b14208a517e73370882005132b393ca2">
                      <SHORT-NAME>SatNoInAttitudeRTK_SatNoInAttitudeRTK_SatNoInAttitudeRTK_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb49ea05ce12383db950eacb93047a2a">
                      <SHORT-NAME>SatNoInPositionRTK_SatNoInPositionRTK_SatNoInPositionRTK_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9644dde86973d01aec15e8a539c1446">
                      <SHORT-NAME>SatNum_SatNum_SatNum_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="79f44ba2b4fe37748a34e58e5e1fabc8">
                      <SHORT-NAME>SecuKeyVldSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="8dc00a07cd6a31b5b75643679c5cf697">
                      <SHORT-NAME>SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="c15a20c64c993b18966858dc182e91b0">
                      <SHORT-NAME>SecySSBAV_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3569c1e2c14c333ab1998ae1ec653118">
                      <SHORT-NAME>SecySSBA_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d1353290fc2a3310aa581e4e0804d67e">
                      <SHORT-NAME>SideLghtOnReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d4ef30104a23fd9a11bf3b85312a828">
                      <SHORT-NAME>SideLghtSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d7cfb95e814e37adafd145178555592c">
                      <SHORT-NAME>SmrtKey4LoctnResp_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6564ecd66e7397688cf880eaa15682b">
                      <SHORT-NAME>SmrtKeyLoctnFlrRsn_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a1b136a7130347bb90a69abb18346c0">
                      <SHORT-NAME>SmrtKeyLoctnProc_LHZCU_10ms_Group32_LHZCU_10ms_Group32_LHZCU_10ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d957134507c439d18c20544d00d7b486">
                      <SHORT-NAME>SpdAstCndStsCamr_SpdAstCndStsCamr_SpdAstCndStsCamr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba5ce8f44aad3ad5b595b9749f8f472a">
                      <SHORT-NAME>SpdAstSysTrgtSpd_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8338737ccdce366cbf32afab8e0e04e3">
                      <SHORT-NAME>SpdLimitManualSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38ce2f62d3d731059ccfa3f8e9d5a2db">
                      <SHORT-NAME>SpdLmtMdFICM_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af708e934b363998b423d90326d508d1">
                      <SHORT-NAME>SpdLmtMdMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4109ec66736d3f9695725b8a78ad3f37">
                      <SHORT-NAME>SpdLmtMdResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e676abfcbbf835c29444e8e39b8d147d">
                      <SHORT-NAME>SpdLmtNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1131495557aa368cb22503a5b64fbe0e">
                      <SHORT-NAME>SpdLmtOfstSetNumReq_SpdLmtOfstSetNumReq_SpdLmtOfstSetNumReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="548d6bebb67836d5822b3645052be233">
                      <SHORT-NAME>SpdLmtOfstSetNumResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0eaf099a3a393ad6a96b6c8635b326d7">
                      <SHORT-NAME>SpdLmtOfstSetPercReq_SpdLmtOfstSetPercReq_SpdLmtOfstSetPercReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="92241fead1e530728a78bcf3a658eab0">
                      <SHORT-NAME>SpdLmtOfstSetPercResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f23670d1d4f03aaf9f3c248360b89db2">
                      <SHORT-NAME>SpdLmtOfstSetReq_SpdLmtOfstSetReq_SpdLmtOfstSetReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66250f12d8b3315795329c9f4fdb929a">
                      <SHORT-NAME>SpdLmtOfstSetResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c2865e6da433ee8a3543d0d771e18f1">
                      <SHORT-NAME>SpdLmtPathRngNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d227ea10fb6351898d9cef96c5588cf">
                      <SHORT-NAME>SpedRegulaModSwReq_SpedRegulaModSwReq_SpedRegulaModSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d1d882f9cd843d90948d1718e23201ec">
                      <SHORT-NAME>SpedRegulaModSwSts_SpedRegulaModSwSts_SpedRegulaModSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54b6852d68eb34b3bdf30933660180e6">
                      <SHORT-NAME>SpfngDet_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f3701c05b5b31bb87675377673632e1">
                      <SHORT-NAME>StrgWhlTipcSwDataIntgty_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0fede0d34cc539aa96360d7f1ed0c9d9">
                      <SHORT-NAME>SvGroup_SvGroup_SvGroup_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53b55721a69b30c39240da667024075b">
                      <SHORT-NAME>SwStaE2EErr_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff37b36e1d973c11912b2a9e903f254b">
                      <SHORT-NAME>SyncMsgCheckSum_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="beba4534f77f34ad94ce8840744f04b1">
                      <SHORT-NAME>SyncMsgOVS_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53ff98dfbcd13ae2b491ca62ed74f846">
                      <SHORT-NAME>SyncMsgSGW_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca22b6a34b9b30cb88b04a37ba2822f0">
                      <SHORT-NAME>SyncMsgSequenceCounter_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27244d215e12353e9a44fd2b1ed4af5f">
                      <SHORT-NAME>SyncMsgTimeDomain_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1e0bbf7bc513db59f546e8961cc399b">
                      <SHORT-NAME>SyncMsgTime_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="113274b103853895bf6c6f0d471ad62e">
                      <SHORT-NAME>SyncMsgType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7310679692e934d68a8d0c4719b7c272">
                      <SHORT-NAME>SyncMsgreserved_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8830881daecf34609d0b07d43a8c422c">
                      <SHORT-NAME>SysOpnlMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e500f9562dc630d29b72195040c6b084">
                      <SHORT-NAME>SysPwrMdCtrl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6a5af1d022c332fb3e3b0e4646565d5">
                      <SHORT-NAME>SysPwrMdV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b05653a062739f7b13cddc6d394b61d">
                      <SHORT-NAME>SysPwrMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7fa77ec80cbb38a284d279a7485b8f5a">
                      <SHORT-NAME>SysVolMdV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94222b8a059a3ce0ab6c2a071e87f3de">
                      <SHORT-NAME>SysVolMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aaa372b58f49398bae9d7c733e76b87c">
                      <SHORT-NAME>SysVolV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3d576965fed3707824bed223a6c9719">
                      <SHORT-NAME>SysVol_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77b4b6b736553298aefa456cfab126ac">
                      <SHORT-NAME>TDMAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1392afd777fd3d45b8d9d2f67ca8f953">
                      <SHORT-NAME>TJAICAMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d46f73baa5a93f009e6e4e2e7a2f8809">
                      <SHORT-NAME>TJAICASysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d08e68f1d89a3cb49330ba2d13cb208a">
                      <SHORT-NAME>TJAICASysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a2aaf3c0276f38618d0184b52734eaf1">
                      <SHORT-NAME>TLRMdSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="245ca2e636b23d438996b9b1a2fb4561">
                      <SHORT-NAME>TLRMdSwReq_TLRMdSwReq_TLRMdSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2827e3ea31fc3bb3b094373be2494068">
                      <SHORT-NAME>TLRMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="041682bcbe633419bf1c8e42aab30316">
                      <SHORT-NAME>TLRSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b7e8084ace63773a42fcbb50c7e43a4">
                      <SHORT-NAME>TLRWarning_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77d28c38b81434c7a0210402af640fab">
                      <SHORT-NAME>TPMSBtmNosRSSI_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97960c653c2e31d78c96786d1f71923a">
                      <SHORT-NAME>TPMSSnsrIDLoctn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a66a8ff52ba2367e911985d10070cf95">
                      <SHORT-NAME>TPMSSnsrID_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d76ae5ed826937f2b289b2a8d84881c7">
                      <SHORT-NAME>TPMSSnsrRSSI_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5da204555a543ca4ba2f16faff7c98c2">
                      <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="32f18e32064a3d6e802bfed8b7d393f1">
                      <SHORT-NAME>TPMSSnsrRdoFrqcCtr_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1188fe3d5363f60bde5a975bcaa73d3">
                      <SHORT-NAME>TPMSWntrMdA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="c9bfd05c8297306bb21213d203c8a812">
                      <SHORT-NAME>TPMS_400ms_PDU06_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="3737fbb416f03588bd1178e05717936a">
                      <SHORT-NAME>TPMS_LHBDEXTDCAN_400ms_FrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="f7ae0c9cf8703bdeaec0bce797d9b25f">
                      <SHORT-NAME>TSRSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5771461f0e1334878cb42dc1720cecb0">
                      <SHORT-NAME>TSRSwReqResp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5242ef01d2b38379c996fe2a8b3e4bd">
                      <SHORT-NAME>TSRSwReq_TSRSwReq_TSRSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cba1becce7b03fe7830bf241b5870eac">
                      <SHORT-NAME>TSRTrgtBanSign_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cfa1f460dcf93c7d95947df29ee55f89">
                      <SHORT-NAME>TSRTrgtWarnSign_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30ec9b287d2a33369a20b673221aa36f">
                      <SHORT-NAME>TemSnsrHdwrFltPrst_TemSnsrHdwrFltPrst_TemSnsrHdwrFltPrst_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="bf8a9e5e5f4035cd8ccfa11de6f6eab9">
                      <SHORT-NAME>Tester_ECM_SFCANFD_10ms_FrP20_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="b04c7ec6aa9f35c8a0b662f991ab997c">
                      <SHORT-NAME>Teter_ECM_10ms_PDU20_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="19096ae7985e39f5aec4818a545108e1">
                      <SHORT-NAME>TgtParkingChosed_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0f737300338388e893bc5f7cf8a2927">
                      <SHORT-NAME>TgtParkingFavorite_TgtParkingFavorite_TgtParkingFavorite_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cc2f3f0510bc33b0a5fd0bbaa6d02091">
                      <SHORT-NAME>TrPfShftPtrnSw1A_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="259a31e440ea399988267a9811b03b79">
                      <SHORT-NAME>TrPfShftPtrnSw2A_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d925cd6584f3357a7c801ba01a2c5f0">
                      <SHORT-NAME>TrPfShftPtrnSw3A_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4dda819255a32bf99119076c6309e91">
                      <SHORT-NAME>TrPfShftPtrnSw4A_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9bbd7aa76ee39568ef2305bb0828921">
                      <SHORT-NAME>TrdtnKeyBtnSts_TrdtnKeyBtnSts_TrdtnKeyBtnSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eaf8479f5b663542924a88a5b086221c">
                      <SHORT-NAME>TrdtnSmrtKyFindCarSwSts_TrdtnSmrtKyFindCarSwSts_TrdtnSmrtKyFindCarSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="119bf5bc9e0a3ca9b52382567652bb79">
                      <SHORT-NAME>TrdtnSmrtKyLckSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a62a8bb354f7301c875af710aacb1d16">
                      <SHORT-NAME>TrdtnSmrtKyLdspcSwSts_TrdtnSmrtKyLdspcSwSts_TrdtnSmrtKyLdspcSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a6cf59268b93a8abbeba422ba5caae6">
                      <SHORT-NAME>TrdtnSmrtKyUnlckSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b6d3b7b45bf391ca9f38e478cd96fd6">
                      <SHORT-NAME>TrfGreenLghtActn_TrfGreenLghtActn_TrfGreenLghtActn_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="570c70e4c53833c9b9858c13ed2ac10e">
                      <SHORT-NAME>TrfcForbidDist_TrfcForbidDist_TrfcForbidDist_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39e7c8f1cba83e58abdd89c2436a4161">
                      <SHORT-NAME>TrfcInfoSignDist_TrfcInfoSignDist_TrfcInfoSignDist_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba76284ffc86337a921f9131b56ac0c1">
                      <SHORT-NAME>TrfcJamRngNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a931df75ba3a30d8bf4b2859566f3713">
                      <SHORT-NAME>TrfcLghtFuctionSwReq_TrfcLghtFuctionSwReq_TrfcLghtFuctionSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b55380407b9a30419cde6cb6a0f9176d">
                      <SHORT-NAME>TrfcLghtFuctionSwSts_TrfcLghtFuctionSwSts_TrfcLghtFuctionSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="974d2fa29943316183e90b3c3a50b4c2">
                      <SHORT-NAME>TrfcLghtStSp_TrfcLghtStSp_TrfcLghtStSp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e5a07d5c7803db18277b43ef961dbd5">
                      <SHORT-NAME>TrfcMrgdForbidDist_TrfcMrgdForbidDist_TrfcMrgdForbidDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="57887cfc354534a6be32d54cfac8c49d">
                      <SHORT-NAME>TrfcMrgdForbidSign_TrfcMrgdForbidSign_TrfcMrgdForbidSign_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d791c90e5baf3662a35f232258c6d949">
                      <SHORT-NAME>TrfcMrgdInfoSignDist_TrfcMrgdInfoSignDist_TrfcMrgdInfoSignDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9613f0a68d8d3182a1a2cbacb6deb3e3">
                      <SHORT-NAME>TrfcMrgdInfoSign_TrfcMrgdInfoSign_TrfcMrgdInfoSign_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a52db8f75113d2099e51aeb82bacd35">
                      <SHORT-NAME>TrfcMrgdWrnngSignDist_TrfcMrgdWrnngSignDist_TrfcMrgdWrnngSignDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38181017129e35598868b18089d77cf5">
                      <SHORT-NAME>TrfcMrgdWrnngSign_TrfcMrgdWrnngSign_TrfcMrgdWrnngSign_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a1168f7bd70634c7b882e1cd6707f185">
                      <SHORT-NAME>TrgtCndSpdReqCamr_TrgtCndSpdReqCamr_TrgtCndSpdReqCamr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce87582eb0fa3409a7f92cb9d4cf89f7">
                      <SHORT-NAME>TrgtSpdSrcSts_IPD_TrgtSpdSrcSts_IPD_TrgtSpdSrcSts_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b64edd3c4aa4377298366dfc01f39358">
                      <SHORT-NAME>TripCntResetReq_TripCntResetReq_TripCntResetReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db24afdf78fb38dfa473d510e0830065">
                      <SHORT-NAME>TripCnt_TripCnt_TripCnt_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5377e9f138b3c69a6c44426005bac33">
                      <SHORT-NAME>TrlrMdSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4fd8750e6bc359696a89d6ac798165d">
                      <SHORT-NAME>UsgMdV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1efbf6c3856305a91c771ad229a426c">
                      <SHORT-NAME>UsgMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c1af394277393e20a9b1b7b8bc1af799">
                      <SHORT-NAME>Vdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="29003e2d1a103bdaa2d6b064ed9bb005">
                      <SHORT-NAME>VehBkwdSwReqV_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="67a7ddfe54e3373594d6b69913f6d3ea">
                      <SHORT-NAME>VehBkwdSwReq_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e9adbcb976a3b189b1cfd695c23903d">
                      <SHORT-NAME>VehDrvngMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72eda41f420434c18998eb94e49893b5">
                      <SHORT-NAME>VehFwdSwReqV_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c792ef31b43c35dcbc78e2de65e867fb">
                      <SHORT-NAME>VehFwdSwReq_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c34a2cc0c5330de815bd411ff8e4a1c">
                      <SHORT-NAME>VehHzrdMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8a54b33b2051379392944d2d44fc6498">
                      <SHORT-NAME>VehIlluminateCtrlCmd_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf31bdc23fb03c7a919e7bb5e4ce576a">
                      <SHORT-NAME>VehLckSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="25b922b04fb830dab01a314acc193b79">
                      <SHORT-NAME>VehLdShedLvl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d155f126a74a3f778f54e13769d38717">
                      <SHORT-NAME>VehMdV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50a61ec01be031879a7a09dcbc4de02e">
                      <SHORT-NAME>VehMd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8536641a0d7335d99f8772e4b4319d3">
                      <SHORT-NAME>VehOdoV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbb34c2fcbfc3cd5b5e087ccfc3b7059">
                      <SHORT-NAME>VehOdo_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f152ed5bfbc737e79fd982762224b9d3">
                      <SHORT-NAME>VehRoadWhlLReqV_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f416adb03353a6f8ec3c4c4cc495e34">
                      <SHORT-NAME>VehRoadWhlLReq_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="29baa303d4e83ff8817b24a4406486e7">
                      <SHORT-NAME>VehRoadWhlRReqV_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da0d2abcfbe830a08ff6fa71441b747c">
                      <SHORT-NAME>VehRoadWhlRReq_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc11c5bfd3d635a487ae09c5e01a6f99">
                      <SHORT-NAME>VehSideLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa5b1b13c0d13276a13584358835436c">
                      <SHORT-NAME>VehTiPblshDay_VehTiPblshDay_VehTiPblshDay_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72b26ce9227c3e0e96ce2a0098f35cc4">
                      <SHORT-NAME>VehTiPblshHr_VehTiPblshHr_VehTiPblshHr_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51d807fc8f1d338fbe78e92a8b5a92bb">
                      <SHORT-NAME>VehTiPblshMins_VehTiPblshMins_VehTiPblshMins_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="843a5c49abd23e4d902b20b56593ad03">
                      <SHORT-NAME>VehTiPblshMth_VehTiPblshMth_VehTiPblshMth_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3da533e589c838d1b25f106b86d5e80e">
                      <SHORT-NAME>VehTiPblshSec_VehTiPblshSec_VehTiPblshSec_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9867031bb69399f8e30dc44644346f8">
                      <SHORT-NAME>VehTiPblshYear_VehTiPblshYear_VehTiPblshYear_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a091944f2c613ba88c63c76ee38b068a">
                      <SHORT-NAME>Veldownsigma_Veldownsigma_Veldownsigma_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="537efc11d94b3079a02e68825445d977">
                      <SHORT-NAME>Veleastsigma_Veleastsigma_Veleastsigma_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e83f203d3133a9880bac3dfa8ae17a8">
                      <SHORT-NAME>Velnorthsigma_Velnorthsigma_Velnorthsigma_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a33b407fd6d3e8fbd3ca219acd34c73">
                      <SHORT-NAME>YawnStatus_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="942364b5d8993877bc08289812e571c7">
                      <SHORT-NAME>ZXD_100ms_PDU76_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="4e23a8fdc85f34c4b8cc9ae3a17d6d1d">
                      <SHORT-NAME>ZXD_100ms_PDU77_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="0985b4e06beb393e8417da8a9dbed689">
                      <SHORT-NAME>ZXD_BKBCANFD_100ms_FrP257_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a9ae2e5630eb3214a6dc36c92c84587d">
                      <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP76_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="eacd3108f2a231bda3411c367678a120">
                      <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP77_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="da816fe8331e356495ea7f9a88a6e0ea">
                      <SHORT-NAME>ZXD_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                  </ECU-COMM-PORT-INSTANCES>
                </CAN-COMMUNICATION-CONNECTOR>
                <CAN-COMMUNICATION-CONNECTOR UUID="Oa505a3f19f25843c4b390f26xOa505a3f19f25843c4b390f7200">
                  <SHORT-NAME>IPD_CHCANFD</SHORT-NAME>
                  <COMM-CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_CHCANFD1</COMM-CONTROLLER-REF>
                  <ECU-COMM-PORT-INSTANCES>
                    <I-SIGNAL-PORT UUID="21e4693420f13ab3b15608c59c60106b">
                      <SHORT-NAME>ABSA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a3d124afd7f336a8b82e62a88b568125">
                      <SHORT-NAME>ABSF_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="261eee8fe9ee3015a32b1439d4beeac1">
                      <SHORT-NAME>ABSIO_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bc175c07cee630b4bc5bfe6270e5954d">
                      <SHORT-NAME>ACCAccReqSts_CH_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c91ea3f85a3a3ebeabc81c6efc49f78b">
                      <SHORT-NAME>ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bb166f64393f312ea13b47f0b76b5396">
                      <SHORT-NAME>ACCAccReqVal_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50b5d11afeb43f91a0b048794ee7db9f">
                      <SHORT-NAME>ACCBrkngA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2321ea8f092038488fdba168c551a93e">
                      <SHORT-NAME>ACCGoReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0e67ce8405a3510806628d3bb238186">
                      <SHORT-NAME>ACCSdslReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb15eb7ca9c034a689be9a80e4e9d08b">
                      <SHORT-NAME>ACCStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26719ad179d4394f95c42c237cb34353">
                      <SHORT-NAME>ACCSysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="64b0b59781b73e31a6925f3c1afc6ccc">
                      <SHORT-NAME>ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab32815a4ffe33759424bdddd106d33e">
                      <SHORT-NAME>ACCSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d42041d0c9b2323b8fd7c623e19001ce">
                      <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b570cd49624d3424a66cf6fe7f5cede5">
                      <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2721a1925efd36e780edebeb2ad3517f">
                      <SHORT-NAME>ACSFCatgrAStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0ec38a02ff5133558b9399616513394b">
                      <SHORT-NAME>ACSFCatgrB1StsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="522c88a984a83c48bee1a10b43807f3f">
                      <SHORT-NAME>ACSFCatgrB2StsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c094b24889cc3c4a8b9763f0a63a0b29">
                      <SHORT-NAME>ACSFCatgrCStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5bde5822ee683a48adf2d1e0ea7324d1">
                      <SHORT-NAME>ACSFCatgrDStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2f537d3e2063b7bb809f53c9a050f90">
                      <SHORT-NAME>ACSFCatgrEStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e0849978d6e352097f899a3e5aa8b59">
                      <SHORT-NAME>ADASStrgDlvrdToqV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d4a0da7cce139a093b14f8eb9f3b139">
                      <SHORT-NAME>ADASStrgDlvrdToq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="76fcca500b9232f3b3e323cc1d15ca2e">
                      <SHORT-NAME>AEBBrkJerkLvlReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c389d83b738315693f7bb25a60ae59c">
                      <SHORT-NAME>AEBDclReqSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87cc42feb40f3bd1ac969902b87f3956">
                      <SHORT-NAME>AEBDclReqToqVal_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="63b5bf20971836d89a4ed7ad00e8fbea">
                      <SHORT-NAME>AEBDclReqVal_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9ae83660f633db89d0f276fa2150752">
                      <SHORT-NAME>AEBHydBrkAstLvlReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f348d46473b3a179e4ab2b03f51e932">
                      <SHORT-NAME>AEBPrflReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2beb25b21bcb3e66aac78790c4fbd92f">
                      <SHORT-NAME>AEBStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47e44bfc11113122a2c81f7337f2fa91">
                      <SHORT-NAME>AEBSysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b637614eee1c3b81bd3a61e08e729c53">
                      <SHORT-NAME>AEBSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="463feecb34ab319193544bee89010a36">
                      <SHORT-NAME>AIPkgAPASCSAcclReqVal_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0465d9d0ba0236c2ad1ba5f4594a0ef5">
                      <SHORT-NAME>ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ddfea6c2b2a63fd9bdf00f5ecdd0d377">
                      <SHORT-NAME>ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a66da33826b3fc294e2e8df4d05cdaa">
                      <SHORT-NAME>APACmdEPSSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04c58ddff5313854a754f164a37b4898">
                      <SHORT-NAME>APAEPBOPReqV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c368b01f3a8d36978c1f8168835eac15">
                      <SHORT-NAME>APAEPBOPReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9567535204de3693987d26f7617ba0c4">
                      <SHORT-NAME>APAEnRunReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="10b22571ba8e37d1ab123f4c54ade9f7">
                      <SHORT-NAME>APAF_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9b09d9f88b4837a2a2f8d8571131ee3c">
                      <SHORT-NAME>APASCSAcclReqSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="117e74b780dc32419b89d81ad6998ad8">
                      <SHORT-NAME>APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34b42a62e83a3036bbbb1da71daaaee5">
                      <SHORT-NAME>APASCUReqStsV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="09785ccf837137369a97ea8f566afa68">
                      <SHORT-NAME>APASCUReqSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68ab722d8d9e31ccb1df8e98408dd1b5">
                      <SHORT-NAME>APAShifterPosReqdV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c0cfadb70073ffe8c0ed66df82a2ca1">
                      <SHORT-NAME>APAShifterPosReqd_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c4b356a2c7c43366b54f84315fdccc64">
                      <SHORT-NAME>APASts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="56ba393098aa3a189174ce9beff84188">
                      <SHORT-NAME>APATrgtEPSStrgWhlAng_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e163cae4fb9b3bc9a8c9be5e8ff28ff3">
                      <SHORT-NAME>APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1e53c87646635299006ce9b32fb4733">
                      <SHORT-NAME>APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e453093d2c653737834d63694a6c5059">
                      <SHORT-NAME>APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="85be7293b3233c548a860be886e5eb4a">
                      <SHORT-NAME>AVHSigPdlSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b880245b6bf63eb98226b56c216414d2">
                      <SHORT-NAME>AccelerationXsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c593ba7b4a83bd59974a201713eb812">
                      <SHORT-NAME>AccelerationXsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bd73bb1e5f43f7385122eeebf53b203">
                      <SHORT-NAME>AccelerationYsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f2cc3263be43f15afdcbe4f1b8a1321">
                      <SHORT-NAME>AccelerationYsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3de6869deb1738069d57e87bd94f9a52">
                      <SHORT-NAME>AccelerationZsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9ea1b7d067b364fa40079f4a0368769">
                      <SHORT-NAME>AccelerationZsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c29babf609630de93aad132b9bb2c6b">
                      <SHORT-NAME>ActuPnonAngV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4988f4a0226636cab7e81c2f8bf17bee">
                      <SHORT-NAME>ActuPnonAng_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2cc640ddacf337dba2bfbcd656b0df17">
                      <SHORT-NAME>ActuRoadWhlAngGrdV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="421c388ca86036338ccc079661cc29cc">
                      <SHORT-NAME>ActuRoadWhlAngGrd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="76a341c1fd1f3aca958fec6f1a87b997">
                      <SHORT-NAME>ActuRoadWhlAngV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cc610df555773d91a12cb6f3640895e4">
                      <SHORT-NAME>ActuRoadWhlAng_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24505454eaf234298980cefb3ba50763">
                      <SHORT-NAME>AngularRateXsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87b74683a00234a38eeaca2887b5d923">
                      <SHORT-NAME>AngularRateXsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aab5386e248b30fba54d295dd28baeef">
                      <SHORT-NAME>AngularRateYsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c428e03754373f63b5ce3d7518e48f14">
                      <SHORT-NAME>AngularRateYsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db3f86bb408839c5aa554c093cb9ed06">
                      <SHORT-NAME>AngularRateZsecinfoV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af646726170236139d25286b68fa3562">
                      <SHORT-NAME>AngularRateZsecinfo_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="882060fc784a3d379d961ba4809e1866">
                      <SHORT-NAME>AutoHoldMdSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19e1db1230143695b57238f59daeff1b">
                      <SHORT-NAME>AutoHoldMsg_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e8798fdad6733a284afad1c2d39d3a0">
                      <SHORT-NAME>AutoHoldSysSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a68728f98ab3df69dd99a86dc28e00a">
                      <SHORT-NAME>AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b8d7c0e67af34bf99fe7357782c48df">
                      <SHORT-NAME>AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="edd1765673773148b391727ff34b710f">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReqV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ed4e8deadb63cc3b015b0e784cb82fc">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66cb16f274ba33a2a4758184a8d8249e">
                      <SHORT-NAME>AutodDrvngSysFlrStsV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e090255a7013dba8aae0a3c666790cb">
                      <SHORT-NAME>AutodDrvngSysFlrSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8b05f8bb91a3d1696c4542d19c1d7cc">
                      <SHORT-NAME>AutodDrvngSysMdReqRespV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31c2851cac65333d8c79324daa0b2b78">
                      <SHORT-NAME>AutodDrvngSysMdReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9673a5d05d53d5cb1b176f724f22696">
                      <SHORT-NAME>AutodDrvngSysMdReqV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bdf99125417359bb4e70d16020ebd38">
                      <SHORT-NAME>AutodDrvngSysMdReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53fb11ca613d343d82d06d9a7c7a9b55">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75d54273e0b331138fdf014aa4b1619e">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b4ba6dcb016c3846b3372791bf46d13c">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReqV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3e885549280343584634694e35ad0af">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04450b88080a391bbfa0a9bcbaa499bd">
                      <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="261e6159e64a3c6fad21e28c770248d9">
                      <SHORT-NAME>AutodDrvngSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3621b6de93643d97a5776948fa8e6c59">
                      <SHORT-NAME>BrkBstFnSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73180d27cf1634d287ec9396214444be">
                      <SHORT-NAME>BrkDiscTemSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b474b49e6f373959b237455363fbcd0f">
                      <SHORT-NAME>BrkFltAlrm_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5014606b8c2f37a0b2cb0b5a94d95965">
                      <SHORT-NAME>BrkFludLvlLowV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c532d5561a43c5b8bc333b2fa756b87">
                      <SHORT-NAME>BrkFludLvlLow_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d2ab7bbc5b63445a2cc32f8c84c2853">
                      <SHORT-NAME>BrkFrc_GB_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81312de3545330c6b2d2023a05036a73">
                      <SHORT-NAME>BrkPdlAppdV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="091ba0e04d08329a947658ff60e49f99">
                      <SHORT-NAME>BrkPdlAppd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69220d4ddb2530e6af42becf426421da">
                      <SHORT-NAME>BrkPdlDrvrAppdPrsDetV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9317d2fe393a3c6b8ef2acbad0f5bc6f">
                      <SHORT-NAME>BrkPdlDrvrAppdPrsDet_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5b689ff33b7366db5db6a37bd61ccac">
                      <SHORT-NAME>BrkPdlDrvrAppdPrsV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="15b5500afb8d3fdc99ab184650fd89ad">
                      <SHORT-NAME>BrkPdlDrvrAppdPrs_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a93d2291ed432249ad09838cd34fe63">
                      <SHORT-NAME>BrkPdlMdlActSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b096f18cb7a3c01bdbcd563aad418f6">
                      <SHORT-NAME>BrkPdlMdlSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="16f1fa8cdf313f299e13a8612e475691">
                      <SHORT-NAME>BrkPdlPosV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54114bb3a98230d39f53b73a0e44b6d3">
                      <SHORT-NAME>BrkPdlPos_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e7a5f94065e3fe38c0b6f9cad0aadf6">
                      <SHORT-NAME>BrkPdlSimltdPrsV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6864782456be33c6a6b042a6708795c4">
                      <SHORT-NAME>BrkPdlSimltdPrs_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65f7dd33689536f1983dd11755ea7ade">
                      <SHORT-NAME>BrkSysBrkLghtsReqd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="98f4c7b43dee3d12b47b18e0c9314d34">
                      <SHORT-NAME>BrkSysHillStAstAvlbl_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b584fb6f63a739d0a063a2f6da6db551">
                      <SHORT-NAME>BrkSysHillStAstSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fdf7a27e2ae73da6af7a28443acf54e7">
                      <SHORT-NAME>BrkSysRddySysSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f07a2ccdfaf938789715ef3476d87898">
                      <SHORT-NAME>BrkSysRedBrkTlltReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5431485805093cb48073e8f1b55d9859">
                      <SHORT-NAME>BrkSysYlwBrkTlltReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a16743360cb937ffbaa819d5f5017c62">
                      <SHORT-NAME>CHLKAHptResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1995db575d4633509e2cec031d40082e">
                      <SHORT-NAME>CSFStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="daef97a7a01e36438a999ae466d52702">
                      <SHORT-NAME>ChACCAccReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8fc95452dda35b1b19a7974af42b45f">
                      <SHORT-NAME>ChACCReqFlrSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9fd8596ce8c3388ebae9b0d4dee1b9b1">
                      <SHORT-NAME>ChAEBBrkJerkReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bf2bf5fa1583862a88f03c848047074">
                      <SHORT-NAME>ChAEBDclReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9c2394fccba365da69cd3548b7c2880">
                      <SHORT-NAME>ChAEBHydBrkAstReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be786e8f5c203c319e1b9b81b537502f">
                      <SHORT-NAME>ChAEBPrflReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee8b19fa0d043317beeab0c64e5aa724">
                      <SHORT-NAME>ChEBADclReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff1df4c1b517308cb7ced736fd1a0187">
                      <SHORT-NAME>ChLKAAngReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e005d3d17e1d36a2ac6a346c8bba5b7a">
                      <SHORT-NAME>ChLKAToqReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd63e3ecf45c3f4c8c484ed7b3502d6e">
                      <SHORT-NAME>ChRCTBDclReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c77f87334fd3236b79caa77e7e75d39">
                      <SHORT-NAME>ChRCTBPrflReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f000bf76a8383871b67f02b6ebf4980a">
                      <SHORT-NAME>ChSysEnToqReqProtn_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dff0be397c4c3689b0a7c4ffff9685a5">
                      <SHORT-NAME>ChSysSecyBrkAxleToqValV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c8d6360f838358d97f4da1be2980fcf">
                      <SHORT-NAME>ChSysSecyBrkAxleToqVal_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74c5022a214537e6a4ebffbbc17edbbf">
                      <SHORT-NAME>ChSysTotBrkAxleToqValV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51e5b0e433c435b8b20699425588e566">
                      <SHORT-NAME>ChSysTotBrkAxleToqVal_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7753f82af3d13b7badc7c010ff3551ad">
                      <SHORT-NAME>ChSysTrBrkAxleToqValV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd43d4aaaaf93ae88de6c3fe2792f04a">
                      <SHORT-NAME>ChSysTrBrkAxleToqVal_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6886bb31972d375ebb4b9aeb38668e48">
                      <SHORT-NAME>CsbLvlSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de5835b98d39397d9ea462f299eb421e">
                      <SHORT-NAME>DistRCAvgDrvnRstOcd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d2a8a47b8afa3b88b0806b4d54c1f78f">
                      <SHORT-NAME>DistRCAvgDrvnSrc_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c304048ddc893bf1afd1cf5feb88137a">
                      <SHORT-NAME>DistRCAvgDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21a4739236b1395a91e0377e3993beda">
                      <SHORT-NAME>DistRCAvgDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1e843a7955c3755bcfe69d8a098c221">
                      <SHORT-NAME>DrvrReqOtptRodTrvlSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6eec6933ece8317fb85a72f854375624">
                      <SHORT-NAME>DrvrReqOtptRodTrvl_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c9e8f2b2a4932dd9b022121baef4ea7">
                      <SHORT-NAME>DrvrStrgDlvrdToqV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e573031c56f93da382d09e50fd692716">
                      <SHORT-NAME>DrvrStrgDlvrdToq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="23ab40ad5f8e389aae9b807dcf653242">
                      <SHORT-NAME>EBDA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ed08ca18d6c3b70b3578a0af195d0b2">
                      <SHORT-NAME>EBDFaultSt_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="766e6647d0ce32cfb8d70e69ce7410e6">
                      <SHORT-NAME>EPBAPAAvlbl_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="570ab25e34b83b4c9bc27f7e4f1f3928">
                      <SHORT-NAME>EPBAppcnSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87251eab98593ddc9a508cfe3168978e">
                      <SHORT-NAME>EPBAppcnSts_M_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8fc650aed5ce36e5a72997f8f8e56464">
                      <SHORT-NAME>EPBAvlblySts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="123a3239271a32b3a0e9e982c434b1cf">
                      <SHORT-NAME>EPBCCCanclReqd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75d200433dce3d7dbfaad2c65ab0c73d">
                      <SHORT-NAME>EPBFlrSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0265f4df8439355697221343f2a8a265">
                      <SHORT-NAME>EPBSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eaa953a3006933028900215d969997b1">
                      <SHORT-NAME>EPBSwStsV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73ffa6e66fe634a28e82bb2f0d7a0f7c">
                      <SHORT-NAME>EPBSwSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="139f14fe495d3222be84a2392a827d4c">
                      <SHORT-NAME>EPBSysAudWrnngReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="411352878a2c31319c63982323e72fd7">
                      <SHORT-NAME>EPBSysBrkLghtsReqdA_IBS_10ms_Group04_IBS_10ms_Group04_IBS_10ms_Group04_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e25c8952550a3faa80c30e8d07f0cef9">
                      <SHORT-NAME>EPBSysDspMsgReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0606cfbc0546309781c5c858a5dbe974">
                      <SHORT-NAME>EPBSysStsIndReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6282572e7243647a6055b8dbc118b10">
                      <SHORT-NAME>EPBSysWrnngIndReq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bcbb4295ce193c11987e7beb729a0200">
                      <SHORT-NAME>EPSAESReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee9b3669e0bb33f3b4e29f8f612ca4b1">
                      <SHORT-NAME>EPSAESReqTorRespV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8d411fb0028373c8da5952b81e59238">
                      <SHORT-NAME>EPSAESReqTorResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e1e5a42b53636e59307d401c7f73ab2">
                      <SHORT-NAME>EPSAESStsInh_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d620a62d5b0312498b20ae90c4621ed">
                      <SHORT-NAME>EPSAIPkgAngReqRespInh_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="85373f2c1ea23efc9a02b970f6df02bd">
                      <SHORT-NAME>EPSAIPkgAngReqResp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1e1eba92ae2e3c12a6311f9b58214581">
                      <SHORT-NAME>EPSAIPltAngRespStsInh_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55b25ce983e3346987be7692af8fc052">
                      <SHORT-NAME>EPSAIPltAngRespSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8065882e42f53a6a8d633d866eb09b29">
                      <SHORT-NAME>EPSAIPltAvlLvl_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3109456a5a2b3190bb5b77999f671ca1">
                      <SHORT-NAME>EPSAIPltCtrlChannel_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="023242158eb03143a0019ee167b0ff3f">
                      <SHORT-NAME>EPSAPAInh_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="745e93791ff23b86ba0d852952f0595e">
                      <SHORT-NAME>EPSAPASts_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f026357d15c332591744ab42d7f722d">
                      <SHORT-NAME>EPSActRetMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4e51106298e31f1b02d9f46a174bcd9">
                      <SHORT-NAME>EPSActRetMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21208e3ecea034ed9ab9e01eff1455bb">
                      <SHORT-NAME>EPSCTTX_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f57e8c5a22f13fd3971a7df98e731ca7">
                      <SHORT-NAME>EPSCoDrivingSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77d3efce92a5303baf2edb705750b0d4">
                      <SHORT-NAME>EPSCurntDrvMd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd0526ad6c0039739e6256c7ba2386f8">
                      <SHORT-NAME>EPSDrvngMdCtrlInh_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8092304d9b6c345c8ddcdc5f7eaf7c04">
                      <SHORT-NAME>EPSFlrSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba6316e117f13a1b8e6e9fb9551d9bc0">
                      <SHORT-NAME>EPSLimMotToqV_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9f1f7da70c233215b96c8368eb2e8948">
                      <SHORT-NAME>EPSLimMotToq_EPS_10ms_Group01_EPS_10ms_Group01_EPS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9bd7ca047323b44a9fc52643875f615">
                      <SHORT-NAME>EPSPriyChnlFlrSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f82b56275ffd34ba95fd382cc9a82cbb">
                      <SHORT-NAME>EPSToqAppdCoefnt_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5d9b13eec6d3410baf2a571989d2902">
                      <SHORT-NAME>EPSToqValAldMaxV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1fab38cafc83d328c3f544fde5804cb">
                      <SHORT-NAME>EPSToqValAldMax_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c9b26aa08b539ffb878fe8effd41740">
                      <SHORT-NAME>EPSToqValAldMinV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d775c121d6543c11bdc5a52a67903715">
                      <SHORT-NAME>EPSToqValAldMin_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="11146dd6977235d1a68ed847ffcf3206">
                      <SHORT-NAME>EPSVMCAngRespSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9bf3d5781ae73aefa8a29a90cf2a3424">
                      <SHORT-NAME>EPSVMCCodrivingSts_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31dfcbe46c2a3df79ba2a151ac38b8e8">
                      <SHORT-NAME>EPSVMCRespStsInh_EPS_010ms_Group03_EPS_010ms_Group03_EPS_010ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9265b41f91e33a2d9a1b5ac33d874c08">
                      <SHORT-NAME>EPS_010ms_Group03_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="339e4d56ca683731a63a1098d796d9c1">
                      <SHORT-NAME>EPS_010ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="acaac8ec6338316682107fee6db9833b">
                      <SHORT-NAME>EPS_010ms_Group03_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cc4f5fcf3e7b39488723bc2ec776f7c3">
                      <SHORT-NAME>EPS_010ms_Group03_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="695f10365c3b39e1ad2d979a71dc46d8">
                      <SHORT-NAME>EPS_010ms_Group03_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c29c3c70cc563004b9652b1dc4ab101e">
                      <SHORT-NAME>EPS_010ms_Group03_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="15b2258963e634d5884ca73ec78cde2a">
                      <SHORT-NAME>EPS_010ms_PDU03_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="6e64e35c224035df9de110b62a6d3d2a">
                      <SHORT-NAME>EPS_10ms_Group01_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9390992d45d33a5a24e891abd7775a7">
                      <SHORT-NAME>EPS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59ea02b131ec3986a797f54ac4798d5d">
                      <SHORT-NAME>EPS_10ms_Group01_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e17d493b51f53a64ac333e0a85e6eefc">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f186af94838539399cb07e08d88a724d">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce3c684c5e793ec99bda36372b747b5e">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c907fdca88c43bfdad7c5d8763895309">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8ff3136db7e23ae492ec18c04b1bd944">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="922e0f28587a380789d8f0322c500a61">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved6_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="983ccf5caf093fb2bfeee5edab137750">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved7_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6771647db5ce39509a75a0e164b0406e">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved8_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30d1b31466723ed99c6be1379a1937cb">
                      <SHORT-NAME>EPS_10ms_Group01_Reserved9_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fae9714af47c34c9bccf211788a35628">
                      <SHORT-NAME>EPS_10ms_Group02_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa2ee29865753bc89b01ed771a39c3b1">
                      <SHORT-NAME>EPS_10ms_Group02_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0609216c471135979d097fb1d9cae6bf">
                      <SHORT-NAME>EPS_10ms_Group02_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fd5d7e3e5383a428314792bb871747f">
                      <SHORT-NAME>EPS_10ms_Group02_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f298d102e1fa3b7394d05e46c3da6f54">
                      <SHORT-NAME>EPS_10ms_Group02_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="faf2748e667e3e64a9d76a4b8f6c07a4">
                      <SHORT-NAME>EPS_10ms_Group05_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3683111202f631ad83c97a0951386e39">
                      <SHORT-NAME>EPS_10ms_Group05_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd6dc8313c833a21ae9424411556fae8">
                      <SHORT-NAME>EPS_10ms_Group05_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f6713b06ce7f37b9a29833ae86f37d9a">
                      <SHORT-NAME>EPS_10ms_Group05_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77ad723bab893386a4f91753d7a1d958">
                      <SHORT-NAME>EPS_10ms_Group05_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="675ab3cd35f035af9a3d723be963eb57">
                      <SHORT-NAME>EPS_10ms_Group05_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="e3610c68975f3d63bab07033bc82927b">
                      <SHORT-NAME>EPS_10ms_PDU01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="4d242507b19a385583a7f69916c2af53">
                      <SHORT-NAME>EPS_10ms_PDU02_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="fcc9eb72073534bb9bff5311c08c3689">
                      <SHORT-NAME>EPS_10ms_PDU05_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="6cfeb12fd40739069acf20119fb4fec0">
                      <SHORT-NAME>EPS_20ms_Group03_CRC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4a347e8d3d93b7cba18fee6b437c103">
                      <SHORT-NAME>EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a0a47934230370b93cac5b9bc7df736">
                      <SHORT-NAME>EPS_20ms_Group03_RC_EPS_20ms_Group03_EPS_20ms_Group03_EPS_20ms_Group03_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="edc8baf257e9330185166a3e66ae29b0">
                      <SHORT-NAME>EPS_20ms_Group03_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fcee5335fce335b49def5ba77f3381f3">
                      <SHORT-NAME>EPS_20ms_Group03_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d1d8f0660b3377b9b5f92c0bccb8626">
                      <SHORT-NAME>EPS_20ms_Group03_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73d70cd59e063961abc5140cdd19af1c">
                      <SHORT-NAME>EPS_20ms_Group03_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="237e8e82004230b88213bfc5a7602b5f">
                      <SHORT-NAME>EPS_20ms_Group03_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="259cebdb8cb43f0a9ba723354b16cca6">
                      <SHORT-NAME>EPS_20ms_PDU03_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="e4662bdaec8e3673a60bbd8215a7ab6b">
                      <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b97111fdffc63d2ab582aebf7d1c3c95">
                      <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="23ec4fab4a393d969c8d74f6eea5d527">
                      <SHORT-NAME>EPS_CHCANFD_20ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="42a2b4ed36a43051be3566a384768895">
                      <SHORT-NAME>EPS_CHCANFD_CT_Tx_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="e99847ce3a193b5bae0384adf3bcd1b3">
                      <SHORT-NAME>EPS_CHCANFD_CT_Tx_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="1249245210553358a3be734869a4fe87">
                      <SHORT-NAME>EPS_CHCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="b499ca8040423e588ecc17fbd3c3956c">
                      <SHORT-NAME>EPS_ZONE_CHCANFD_10ms_Container01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="e8ee45bcbad038db9830d91959da3106">
                      <SHORT-NAME>ESFStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cf75f01b1da13c2e8a63468dc98c6206">
                      <SHORT-NAME>ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="807918519ee036a3a452cac3c4ceb7c8">
                      <SHORT-NAME>ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d6209975740e3c40870167cec2cd490d">
                      <SHORT-NAME>ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="275298051fe63df8b749131003c4f301">
                      <SHORT-NAME>ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="036c76f0fddb383b8127b7a3dbdf8f0e">
                      <SHORT-NAME>EmgcBrkAV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="050ba5c1bcf63e37bc69c54523eac31f">
                      <SHORT-NAME>EmgcBrkA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8673be06fdf3b1d9ce98fcd00178279">
                      <SHORT-NAME>EmgcBrkReqdByIECUSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="268ac5ddb577395d833b8842e5fcf3bd">
                      <SHORT-NAME>EnDragToqRducnA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74431627b3fe387b8f874295ce2f405e">
                      <SHORT-NAME>ExtnlBrkPrioV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38246773d24d3df58478a39135ac5162">
                      <SHORT-NAME>ExtnlBrkPrio_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="1b03231143a53245aa4c283d86fbdc56">
                      <SHORT-NAME>FVCM_100ms_PDU05_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="08590323eb603ee289c41a13bac9bca4">
                      <SHORT-NAME>FVCM_10ms_Group01_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84af04076dc43346a7fd47923e1b41e6">
                      <SHORT-NAME>FVCM_10ms_Group01_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02323929367937919abc230bfb4b743d">
                      <SHORT-NAME>FVCM_10ms_Group01_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68d3d5ce4a393c6ba567b5e4401c6b7d">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="03570909318d36d483fa90eec65d3b83">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5103bee655738f383ae12d7e6db50f4">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9b88747b6908364aadcf33fd0a1619b4">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8976060b100f3d6ea77d85258f3e28f0">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5c62831586c315c8516b181c3b58751">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cca909ca89e83ca8bcd71b7833868c40">
                      <SHORT-NAME>FVCM_10ms_Group01_Reserved7_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="0c3fdf2318803061b27fdc78ff296041">
                      <SHORT-NAME>FVCM_10ms_PDU01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="d54f7c2b8f3d3f26b55e3bc477aaf424">
                      <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="ab2efa5aba063ea3a2cfc388f9edc307">
                      <SHORT-NAME>FVCM_BKPCANFD_10ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="dafc1f75f0533863911f9f9d759c349d">
                      <SHORT-NAME>FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12bac0c2cac53a158dad7dbb3ddbe119">
                      <SHORT-NAME>HBAActiveSt_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aebf20e5eeaa3bb9a298cb9f864a9024">
                      <SHORT-NAME>HBAValidSt_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49412bae32ed346d97b100f3fb79e36c">
                      <SHORT-NAME>HDCSysSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d57f7eaff4a35fb947003dd09726c51">
                      <SHORT-NAME>IBSABSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c64bdfc43023afbb049e21c9beca433">
                      <SHORT-NAME>IBSAPASysFltSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c710f4ae499838c8b9f4787c9681fbb7">
                      <SHORT-NAME>IBSESPlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="087195ed6d4f30e5862bf3eccc0eb532">
                      <SHORT-NAME>IBSRespAccToqVal_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c179cf70d473a40abb907b12f4f3191">
                      <SHORT-NAME>IBSTCSlvlResp_IBS_100ms_Group15_IBS_100ms_Group15_IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="126d92ce88f63e07b66465e23ad9ed5c">
                      <SHORT-NAME>IBS_100ms_Group15_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e929897616e53136a85c9e6044be1f0e">
                      <SHORT-NAME>IBS_100ms_Group15_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db4f24b38514379c8bef2ca591fada5e">
                      <SHORT-NAME>IBS_100ms_Group15_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="598db97c70483732be894dd3d1125c28">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d764b4da38383fed907d23adae53533b">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d1368731f69c3aaaa6264f3c4678a6b8">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a540f8c536263ea9b5c78b60241538ae">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4669c3369f336928c4c519e8a5f10a3">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51c4ddfe14633d0cbed6bc5414e7b060">
                      <SHORT-NAME>IBS_100ms_Group15_Reserved6_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="179b8dafd8df35639cdeca7be56e6bfe">
                      <SHORT-NAME>IBS_100ms_PDU15_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="56d74bef9bf33d8daf48f108a1f24767">
                      <SHORT-NAME>IBS_10ms_Group01_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59ce4f24374332d59d0d7a33aea0b823">
                      <SHORT-NAME>IBS_10ms_Group02_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b39dd9dfcef3e84931897caa87d5698">
                      <SHORT-NAME>IBS_10ms_Group04_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b706b5b1a55e31ef9184cf11e458f822">
                      <SHORT-NAME>IBS_10ms_Group04_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c08ce276684f38028d4148dfe3b4c5ea">
                      <SHORT-NAME>IBS_10ms_Group04_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4929232aaae23e648fd0246adafe41df">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74bf78a42fcd3f31b2896057a2070883">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c55be283fcb35938bf70c2fc51834aa">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb09380d88653b918dc2f789c1532d16">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a756e09533ab3110aade273c922716c0">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f6f2da1ec643fd685211fc576653708">
                      <SHORT-NAME>IBS_10ms_Group04_Reserved6_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4b07d358de323a1db15c5fb42a38da8b">
                      <SHORT-NAME>IBS_10ms_PDU01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="176513f511ff377f9534a19afa3d3930">
                      <SHORT-NAME>IBS_10ms_PDU02_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1dceeeddcf3638ef8c6df028f46991a9">
                      <SHORT-NAME>IBS_10ms_PDU04_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="b22f1e0e05f133818b4ec9a24f922f67">
                      <SHORT-NAME>IBS_20ms_Group07_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5501803b2cd030bbb654b9f717eee567">
                      <SHORT-NAME>IBS_20ms_Group07_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b839250873c4374597c6dd577d4fabe4">
                      <SHORT-NAME>IBS_20ms_Group07_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6fba12e1cd943b20853cd2faa96f24dd">
                      <SHORT-NAME>IBS_20ms_Group08_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="05fbbb14d997370eb98dcb1c6278839c">
                      <SHORT-NAME>IBS_20ms_Group08_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91e3b55f08da3460a7e6961747497544">
                      <SHORT-NAME>IBS_20ms_Group08_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="606c7b5e9dc53fd2aa26343869abdae7">
                      <SHORT-NAME>IBS_20ms_Group09_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de09e3f6956130d08da7713f89d24007">
                      <SHORT-NAME>IBS_20ms_Group09_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df6107bf243237acb20dc01a07583867">
                      <SHORT-NAME>IBS_20ms_Group09_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da96e5e4a95a3551bc7775d9098acd82">
                      <SHORT-NAME>IBS_20ms_Group09_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd43c0be06853b8ebb248c5cd0815fdd">
                      <SHORT-NAME>IBS_20ms_Group10_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef1ac43e3baf3cfea6f2a14f726f27b8">
                      <SHORT-NAME>IBS_20ms_Group10_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="979126c8e5b23b9687683c0bfe0aea62">
                      <SHORT-NAME>IBS_20ms_Group10_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="edd6ee619247374f9856af6dd5d5c672">
                      <SHORT-NAME>IBS_20ms_Group10_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6e3d254e8f9439c18c9fe34aab5ac3ff">
                      <SHORT-NAME>IBS_20ms_Group10_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1226e78dc2aa3c4db43b99dc7af3522d">
                      <SHORT-NAME>IBS_20ms_Group11_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9feff6747b33d7ab9f61cbec34ac6a5">
                      <SHORT-NAME>IBS_20ms_Group11_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2f1f6d55b8683d25b70cdb1c3a571caa">
                      <SHORT-NAME>IBS_20ms_Group11_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="452fd6a6c72331609fbd76693d08e584">
                      <SHORT-NAME>IBS_20ms_Group11_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e93645bdb6ac3241b80fdd8214071674">
                      <SHORT-NAME>IBS_20ms_Group12_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d63547b4f98b39a7af1f3549cca1d748">
                      <SHORT-NAME>IBS_20ms_Group12_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="420c3e4df35335bfa455db2ea558705e">
                      <SHORT-NAME>IBS_20ms_Group12_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c91e9ea585e032f3b10582d4305a4509">
                      <SHORT-NAME>IBS_20ms_Group12_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce76a6d4f3b5309bb56d6965b9ed69ba">
                      <SHORT-NAME>IBS_20ms_Group12_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59abff416d5f39cfb6e3e447b213ed98">
                      <SHORT-NAME>IBS_20ms_Group13_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4be6a9a3db1f3caeb7eaca7f6d348a6d">
                      <SHORT-NAME>IBS_20ms_Group13_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6b61d3a9da4e309a9dd188ac3bf8d3aa">
                      <SHORT-NAME>IBS_20ms_Group13_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4c8c46bdec3d304c8ee02333ed46bcd7">
                      <SHORT-NAME>IBS_20ms_PDU07_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="321a92d0810d32af867b2d9e0e294577">
                      <SHORT-NAME>IBS_20ms_PDU08_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f7fcd420daa23fcd8a64adaad2f7d89e">
                      <SHORT-NAME>IBS_20ms_PDU09_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ab4e5e212c213aab918b649d7bf5601d">
                      <SHORT-NAME>IBS_20ms_PDU10_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="7a66673b36063a0bb8fb90e5e15ab963">
                      <SHORT-NAME>IBS_20ms_PDU11_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3bcd9e83c387367b9e90e09d8058ad7a">
                      <SHORT-NAME>IBS_20ms_PDU12_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3bd38e68632432d984de11104db0d333">
                      <SHORT-NAME>IBS_20ms_PDU13_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c6f20f9eb9a737c8844728697ddbf89a">
                      <SHORT-NAME>IBS_20ms_PDU26_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="341f8d744af331ae8d436aa2cf71905e">
                      <SHORT-NAME>IBS_CHCANFD_100ms_FrP15_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="003bffe13d8b3ffda1a14f53ce3c8e30">
                      <SHORT-NAME>IBS_CHCANFD_10ms_ConFrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="3ebe3cdaf6f23cc79073ff79d4a7d793">
                      <SHORT-NAME>IBS_CHCANFD_10ms_Container01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="79bda2ec282931a489d432f46b55986c">
                      <SHORT-NAME>IBS_CHCANFD_10ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="7168af3bb2db3e469654cc9c607505c4">
                      <SHORT-NAME>IBS_CHCANFD_10ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="29caad9ee9a4364c9a9aee60a621e232">
                      <SHORT-NAME>IBS_CHCANFD_20ms_ConFrP10_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="46a23443b6fd3eb7b4b27cdae04d35ec">
                      <SHORT-NAME>IBS_CHCANFD_20ms_Container01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="9ed12e92a9813e9bbd0d084c71712bdd">
                      <SHORT-NAME>IBS_CHCANFD_20ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="82aad4083f723b038bba009d9857d4f4">
                      <SHORT-NAME>IBS_CHCANFD_20ms_FrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f99f10aae3a43c949dfcadb2b714e4bb">
                      <SHORT-NAME>IBS_CHCANFD_20ms_FrP09_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="42a2a193389f3c3d8846b02b52fcd9e4">
                      <SHORT-NAME>IBS_CHCANFD_20ms_FrP11_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5f631908456335c88621d9e4fa2e8d9a">
                      <SHORT-NAME>IBS_CHCANFD_20ms_FrP12_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d11f514f141a3ddf846850fd1fa6630e">
                      <SHORT-NAME>IBS_CHCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="24cda4e68cd63bdfa0106c7d00dd875a">
                      <SHORT-NAME>IBS_SFCANFD_20ms_FrP26_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="04498aa262413c57943f31449329fe78">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_CRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="279b8807355f3fe3b6be8acbe953476f">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6545e7672e7939549571490d9ae16cf3">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_RC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b5ee808a538321aa7c9d5355b35be31">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1916a4dfd9833afb8d5364ae57c40bfd">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4527c7fbacb53c4687326b611417503a">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c50f241f3bdd320a94599a2da47e19ba">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="86d26b26041e35ac82fcd18fc333c2b4">
                      <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="880d7484a2ca360ba36e8c8bf7130934">
                      <SHORT-NAME>IBS_ZONE_20ms_PDU08_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="3324a4470e0f3b3f96c661141463dc29">
                      <SHORT-NAME>IBS_ZONE_CHCANFD_20ms_FrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="7b2d24376ec33f1f8502c6fb9f19ac89">
                      <SHORT-NAME>ICBAD_10ms_Group01_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f26f03e2eef73cfba1b667306502f6b8">
                      <SHORT-NAME>ICBAD_10ms_Group01_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d25e1ae004f33169b447670689745c9">
                      <SHORT-NAME>ICBAD_10ms_Group01_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="689f38807cf9337ebb9d9f739991e242">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved10_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da48451f6f7e39c187b0bf0c7f000bcb">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved11_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55d46a1f603933e0adb772654f1df080">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved12_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22e31e89d0063a0d8f03fb106a4b1bf5">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved13_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8a60b83023b63a38afbcadb9a56bfeb1">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved14_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b4652644f0933bb196e94235f6211fc4">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved15_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="858be782027e3439a239c47bbd8aa66f">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved16_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ef496eaf8f437f0bbf145faf493c84e">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved17_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2007ab1b5c843210a29ed2362b412ab8">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved18_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc3eae32d20e365ea09a2c9909565d61">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved19_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c9dfd65aa44342db9ec45156578fc6f">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6479954bd9743380b54a3eba4809af25">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved20_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cbc2c3d5684d3f87a52a7c4f8463a520">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved21_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="683d14c3f2d7334aa615bb7cd8c50249">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved22_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6d5f9e85468343fb9a42a468588adc7">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved23_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53c6cd7d726f31709be201dc101f729c">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5455ef516f963525843b74443d63242c">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="698d37ca114e32a981c6fb2d67861d1a">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f20aa3b47773955a15a693d6b296716">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a3285b771fa4392b86c3bea968586ba4">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c59dd1496563c93a6eceb4057e3a25e">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved7_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
