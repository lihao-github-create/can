              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3188caXOa505a3f19f25843c4b3188c900">
              <SHORT-NAME>ISatElv8</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite8 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角8
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv8</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv8</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318528XOa505a3f19f25843c4b31852700">
              <SHORT-NAME>ISatElv9</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite9 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角9
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv9</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv9</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318b55XOa505a3f19f25843c4b318b5400">
              <SHORT-NAME>ISatID1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite1 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号1
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3188e9XOa505a3f19f25843c4b3188e800">
              <SHORT-NAME>ISatID10</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite10 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号10
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID10</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID10</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318a7cXOa505a3f19f25843c4b318a7b00">
              <SHORT-NAME>ISatID11</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite11 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号11
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID11</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID11</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317edcXOa505a3f19f25843c4b317edb00">
              <SHORT-NAME>ISatID12</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite12 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号12
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID12</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID12</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318c4dXOa505a3f19f25843c4b318c4c00">
              <SHORT-NAME>ISatID13</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite13 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号13
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID13</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID13</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318509XOa505a3f19f25843c4b31850800">
              <SHORT-NAME>ISatID14</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite14 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号14
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID14</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID14</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3187d2XOa505a3f19f25843c4b3187d100">
              <SHORT-NAME>ISatID15</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite15 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号15
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID15</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318221XOa505a3f19f25843c4b31822000">
              <SHORT-NAME>ISatID16</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite16 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号16
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID16</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID16</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318129XOa505a3f19f25843c4b31812800">
              <SHORT-NAME>ISatID17</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite17 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号17
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID17</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID17</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318a3eXOa505a3f19f25843c4b318a3d00">
              <SHORT-NAME>ISatID18</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite18 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号18
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID18</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID18</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3185c3XOa505a3f19f25843c4b3185c200">
              <SHORT-NAME>ISatID19</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite19 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号19
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID19</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID19</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318775XOa505a3f19f25843c4b31877400">
              <SHORT-NAME>ISatID2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite2 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号2
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318186XOa505a3f19f25843c4b31818500">
              <SHORT-NAME>ISatID20</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite20 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号20
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID20</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID20</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3185e2XOa505a3f19f25843c4b3185e100">
              <SHORT-NAME>ISatID3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite3 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号3
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318c8bXOa505a3f19f25843c4b318c8a00">
              <SHORT-NAME>ISatID4</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite4 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号4
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID4</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318ce8XOa505a3f19f25843c4b318ce700">
              <SHORT-NAME>ISatID5</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite5 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号5
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID5</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318585XOa505a3f19f25843c4b31858400">
              <SHORT-NAME>ISatID6</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite6 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号6
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID6</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317efbXOa505a3f19f25843c4b317efa00">
              <SHORT-NAME>ISatID7</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite7 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号7
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID7</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31846eXOa505a3f19f25843c4b31846d00">
              <SHORT-NAME>ISatID8</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite8 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号8
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID8</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID8</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318794XOa505a3f19f25843c4b31879300">
              <SHORT-NAME>ISatID9</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite9 Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星编号9
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatID9</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatID9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatID9</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318927XOa505a3f19f25843c4b31892600">
              <SHORT-NAME>ISatNoInAttitudeRTK</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SatNoInAttitudeRTK</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:从天线解算卫星数
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatNoInAttitudeRTK</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNoInAttitudeRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNoInAttitudeRTK</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3186f9XOa505a3f19f25843c4b3186f800">
              <SHORT-NAME>ISatNoInPositionRTK</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SatNoInPositionRTK</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:主天线解算卫星数
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatNoInPositionRTK</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNoInPositionRTK</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNoInPositionRTK</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3183d3XOa505a3f19f25843c4b3183d200">
              <SHORT-NAME>ISatNum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellites Number</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:可视卫星数
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatNum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatNum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7180XOa505a3f19f25843c4b2e717f00">
              <SHORT-NAME>ISeatOccptnNum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Seat Occupation Number</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SeatOccptnNum</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SeatOccptnNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SeatOccptnNum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e719fXOa505a3f19f25843c4b2e719e00">
              <SHORT-NAME>ISecRowLOccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Second Row Left Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后排左侧占位状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,SDM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecRowLOccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowLOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecRowLOccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e71beXOa505a3f19f25843c4b2e71bd00">
              <SHORT-NAME>ISecRowMOccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Second Row Middle Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后排中间占位状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,SDM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecRowMOccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowMOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecRowMOccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e71ddXOa505a3f19f25843c4b2e71dc00">
              <SHORT-NAME>ISecRowROccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Second Row Right Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后排右侧占位状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,SDM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecRowROccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecRowROccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecRowROccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3800f2XOa505a3f19f25843c4b3800f100">
              <SHORT-NAME>ISecuKeyVldSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Security Key Valid Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:挡位切换防盗有效性
接收方描述:挡位切换防盗有效性
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecuKeyVldSts</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecuKeyVldSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecuKeyVldSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b6c0XOa505a3f19f25843c4b34b6bf00">
              <SHORT-NAME>ISecySSBA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Secondary_Start_Stop_Button_Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:BKBCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecySSBA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecySSBA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b6dbXOa505a3f19f25843c4b34b6da00">
              <SHORT-NAME>ISecySSBAV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Secondary_Start_Stop_Button_Active_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:BKBCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SecySSBAV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SecySSBAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SecySSBAV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec3cfXOa505a3f19f25843c4b2ec3ce00">
              <SHORT-NAME>IShftSeqStat_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ShftSeqStat_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ShftSeqStat_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ShftSeqStat_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ShftSeqStat_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cfffXOa505a3f19f25843c4b37cffe00">
              <SHORT-NAME>IShwrmComprEnbReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Showroom_Compressor_Enable_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:展厅空调压缩机使能禁用信号
接收方描述:RHZCU（空调）
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ShwrmComprEnbReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ShwrmComprEnbReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ShwrmComprEnbReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378353XOa505a3f19f25843c4b37835200">
              <SHORT-NAME>ISideLghtOnReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Side Ligth On Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:请求ICB路由信号请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SideLghtOnReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SideLghtOnReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SideLghtOnReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e35d3XOa505a3f19f25843c4b2e35d200">
              <SHORT-NAME>ISideLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Side_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:NA
信息安全:null
有无服务标签:
发送方描述:位置灯状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:音响</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SideLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SideLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SideLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cd77XOa505a3f19f25843c4b37cd7600">
              <SHORT-NAME>ISmrtKey1BtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 1 Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:无钥匙进入与启动
每个bit表示一个按键：
bit0=Button 1
bit1=Button 2
bit2=Button 3
bit3=Button 4
bit4=Button 5
bit5=Button 6
bit6=Button 7
每个bit中：
0x0=no press
0x1=pressed</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey1BtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey1BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey1BtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cd92XOa505a3f19f25843c4b37cd9100">
              <SHORT-NAME>ISmrtKey1LoctnResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 1 Location Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey1LoctnResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey1LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey1LoctnResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cde3XOa505a3f19f25843c4b37cde200">
              <SHORT-NAME>ISmrtKey2BtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 2 Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:无钥匙进入与启动
每个bit表示一个按键：
bit0=Button 1
bit1=Button 2
bit2=Button 3
bit3=Button 4
bit4=Button 5
bit5=Button 6
bit6=Button 7
每个bit中：
0x0=no press
0x1=pressed</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey2BtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey2BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey2BtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ce4fXOa505a3f19f25843c4b37ce4e00">
              <SHORT-NAME>ISmrtKey2LoctnResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 2 Location Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey2LoctnResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey2LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey2LoctnResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ce19XOa505a3f19f25843c4b37ce1800">
              <SHORT-NAME>ISmrtKey3BtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 3 Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:无钥匙进入与启动
每个bit表示一个按键：
bit0=Button 1
bit1=Button 2
bit2=Button 3
bit3=Button 4
bit4=Button 5
bit5=Button 6
bit6=Button 7
每个bit中：
0x0=no press
0x1=pressed</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey3BtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey3BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey3BtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cdfeXOa505a3f19f25843c4b37cdfd00">
              <SHORT-NAME>ISmrtKey3LoctnResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 3 Location Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey3LoctnResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey3LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey3LoctnResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cdc8XOa505a3f19f25843c4b37cdc700">
              <SHORT-NAME>ISmrtKey4BtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 4 Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:无钥匙进入与启动
每个bit表示一个按键：
bit0=Button 1
bit1=Button 2
bit2=Button 3
bit3=Button 4
bit4=Button 5
bit5=Button 6
bit6=Button 7
每个bit中：
0x0=no press
0x1=pressed</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey4BtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey4BtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey4BtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e724XOa505a3f19f25843c4b37e72300">
              <SHORT-NAME>ISmrtKey4LoctnResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key 4 Location Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKey4LoctnResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKey4LoctnResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKey4LoctnResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e740XOa505a3f19f25843c4b37e73f00">
              <SHORT-NAME>ISmrtKeyLoctnFlrRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key Search Failure Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKeyLoctnFlrRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKeyLoctnFlrRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnFlrRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e75cXOa505a3f19f25843c4b37e75b00">
              <SHORT-NAME>ISmrtKeyLoctnProc</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart Key Location Process</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmrtKeyLoctnProc</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmrtKeyLoctnProc</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmrtKeyLoctnProc</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34688bXOa505a3f19f25843c4b34688a00">
              <SHORT-NAME>ISmtKeyAuthnMnModRunSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart_Key__Authentication_Platform_Run_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:数字钥匙认证主端认证运行状态信号，做防盗功能
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmtKeyAuthnMnModRunSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmtKeyAuthnMnModRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmtKeyAuthnMnModRunSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3490e1XOa505a3f19f25843c4b3490e000">
              <SHORT-NAME>ISmtKeyAuthnSubModRunSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Smart_Key__Authentication_Smart_Key_Module_Run_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:数字钥匙认证从端认证运行状态信号，做防盗功能
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SmtKeyAuthnSubModRunSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SmtKeyAuthnSubModRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SmtKeyAuthnSubModRunSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366055XOa505a3f19f25843c4b36605400">
              <SHORT-NAME>ISoftSpSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Soft Stop System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:舒适制动系统状态反馈（D车信号拉起）,舒适制动状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SoftSpSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SoftSpSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SoftSpSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e35f2XOa505a3f19f25843c4b2e35f100">
              <SHORT-NAME>ISolarStrngLSide</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Solar Strength Left Side</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SolarStrngLSide</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngLSide</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SolarStrngLSide</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346a8bXOa505a3f19f25843c4b346a8a00">
              <SHORT-NAME>ISolarStrngLSideV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Solar Strength Left Side Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SolarStrngLSideV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngLSideV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SolarStrngLSideV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3611XOa505a3f19f25843c4b2e361000">
              <SHORT-NAME>ISolarStrngRSide</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Solar Strength Right Side</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SolarStrngRSide</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngRSide</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SolarStrngRSide</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346cc2XOa505a3f19f25843c4b346cc100">
              <SHORT-NAME>ISolarStrngRSideV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Solar Strength Right Side Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SolarStrngRSideV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SolarStrngRSideV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SolarStrngRSideV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fa8aXOa505a3f19f25843c4b37fa8900">
              <SHORT-NAME>ISpdAstCndStsCamr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Assist Condition Status Camera</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:FVCM发送的条件限速标志位
接收方描述:SLIF系统输出的条件限速类型
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:PICM 智能限速</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdAstCndStsCamr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdAstCndStsCamr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdAstCndStsCamr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eab78XOa505a3f19f25843c4b2eab7700">
              <SHORT-NAME>ISpdAstSysTrgtSpd_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Assist_System_Target_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR限速数值
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdAstSysTrgtSpd_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdAstSysTrgtSpd_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdAstSysTrgtSpd_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eab97XOa505a3f19f25843c4b2eab9600">
              <SHORT-NAME>ISpdLimitManualSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed limit manual status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLimitManualSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLimitManualSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLimitManualSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c4f4XOa505a3f19f25843c4b34c4f300">
              <SHORT-NAME>ISpdLmtMdFICM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Modle FICM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS 功能开关信号
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtMdFICM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdFICM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eabb6XOa505a3f19f25843c4b2eabb500">
              <SHORT-NAME>ISpdLmtMdMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Limit_Mode_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS文言提示信号
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtMdMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eabd5XOa505a3f19f25843c4b2eabd400">
              <SHORT-NAME>ISpdLmtMdResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Limit_Mode_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS 功能开关信号
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtMdResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtMdResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtMdResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8b02XOa505a3f19f25843c4b2e8b0100">
              <SHORT-NAME>ISpdLmtNav</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Limit_Navigation</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtNav</SHORT-LABEL>
                  <VALUE>0x1F</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtNav</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e84feXOa505a3f19f25843c4b2e84fd00">
              <SHORT-NAME>ISpdLmtOfstSetNumReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Number_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS限速偏移量选择设置（固定值）
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetNumReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetNumReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetNumReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eabf4XOa505a3f19f25843c4b2eabf300">
              <SHORT-NAME>ISpdLmtOfstSetNumResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Number_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS限速偏移量选择显示状态（固定值）
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetNumResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetNumResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetNumResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e851dXOa505a3f19f25843c4b2e851c00">
              <SHORT-NAME>ISpdLmtOfstSetPercReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Percent_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetPercReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetPercReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetPercReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eac13XOa505a3f19f25843c4b2eac1200">
              <SHORT-NAME>ISpdLmtOfstSetPercResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Percent_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetPercResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetPercResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetPercResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e853cXOa505a3f19f25843c4b2e853b00">
              <SHORT-NAME>ISpdLmtOfstSetReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS限速偏移量选择（数值）
接收方描述:FVCM
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetReq</SHORT-LABEL>
                  <VALUE>0x14</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eac32XOa505a3f19f25843c4b2eac3100">
              <SHORT-NAME>ISpdLmtOfstSetResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Offset Set Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS限速偏移量选择
接收方描述:ZXD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtOfstSetResp</SHORT-LABEL>
                  <VALUE>0x14</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtOfstSetResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtOfstSetResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e89ecXOa505a3f19f25843c4b2e89eb00">
              <SHORT-NAME>ISpdLmtPathRngNav</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Limit_Path_Range_Navigation</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpdLmtPathRngNav</SHORT-LABEL>
                  <VALUE>0x7FF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>11</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpdLmtPathRngNav</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpdLmtPathRngNav</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3236a0XOa505a3f19f25843c4b32369f00">
              <SHORT-NAME>ISpedRegulaModSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Regulation Mode Switch request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:限速调控制开关请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpedRegulaModSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpedRegulaModSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpedRegulaModSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324316XOa505a3f19f25843c4b32431500">
              <SHORT-NAME>ISpedRegulaModSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Regulation Mode Switch status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:限速调控制开关状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpedRegulaModSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpedRegulaModSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpedRegulaModSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379e59XOa505a3f19f25843c4b379e5800">
              <SHORT-NAME>ISpfngDet_IMM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Spoofing Detected_IMM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IMM_50ms_Group02
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SpfngDet_IMM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SpfngDet_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SpfngDet_IMM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8d0bXOa505a3f19f25843c4b2e8d0a00">
              <SHORT-NAME>ISprSportSubItemReq</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:沿用P12L M0
信息安全:
有无服务标签:
发送方描述:主动声浪
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SprSportSubItemReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SprSportSubItemReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SprSportSubItemReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8bdbXOa505a3f19f25843c4b2e8bda00">
              <SHORT-NAME>ISprSportSubItemReqV</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:沿用P12L M0
信息安全:
有无服务标签:
发送方描述:主动声浪
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SprSportSubItemReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SprSportSubItemReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SprSportSubItemReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b349382XOa505a3f19f25843c4b34938100">
              <SHORT-NAME>ISrfOpenSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Sunroof Open Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SrfOpenSts</SHORT-LABEL>
                  <VALUE>0x6</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SrfOpenSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SrfOpenSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e1b89XOa505a3f19f25843c4b2e1b8800">
              <SHORT-NAME>IStrgCustSetngDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Customization Setting Display Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:驾驶模式显示
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgCustSetngDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgCustSetngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgCustSetngDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367366XOa505a3f19f25843c4b36736500">
              <SHORT-NAME>IStrgWhlAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL-B,ASIL A
信息安全:
有无服务标签:
发送方描述:方向盘转角
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:VS，外灯，HMI,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367385XOa505a3f19f25843c4b36738400">
              <SHORT-NAME>IStrgWhlAngGrd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Gradient</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:转角变化率，观测,方向盘转角信号,方向盘角度速度
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngGrd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngGrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngGrd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3673a4XOa505a3f19f25843c4b3673a300">
              <SHORT-NAME>IStrgWhlAngSnsrCalSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Sensor Calibration Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:方向盘转角标定状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngSnsrCalSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrCalSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrCalSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3673c3XOa505a3f19f25843c4b3673c200">
              <SHORT-NAME>IStrgWhlAngSnsrFlt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Sensor Fault</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:转角传感器故障,方向盘转角故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngSnsrFlt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrFlt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrFlt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3673e2XOa505a3f19f25843c4b3673e100">
              <SHORT-NAME>IStrgWhlAngSnsrInid</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Sensor Initialized</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:观测,方向盘转角初始化状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngSnsrInid</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrInid</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrInid</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367401XOa505a3f19f25843c4b36740000">
              <SHORT-NAME>IStrgWhlAngSnsrMultCapb</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Sensor Multiturn Capable</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:方向盘转角标定状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngSnsrMultCapb</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngSnsrMultCapb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngSnsrMultCapb</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b367420XOa505a3f19f25843c4b36741f00">
              <SHORT-NAME>IStrgWhlAngV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Angle Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group05
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:方向盘转角有效性
接收方描述:方向盘转角有效性
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS，外灯,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlAngV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlAngV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlAngV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376f5fXOa505a3f19f25843c4b376f5e00">
              <SHORT-NAME>IStrgWhlTipcSwDataIntgty</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBVC_50ms_Group11
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrgWhlTipcSwDataIntgty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrgWhlTipcSwDataIntgty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrgWhlTipcSwDataIntgty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec40dXOa505a3f19f25843c4b2ec40c00">
              <SHORT-NAME>IStrtTypAvail_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">StrtTypAvail_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>StrtTypAvail_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/StrtTypAvail_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/StrtTypAvail_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31b2d4XOa505a3f19f25843c4b31b2d300">
              <SHORT-NAME>ISusDmpngCtrlCustSetngReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Suspension Damping Control Customization Setting Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:产品定义的CDC子功能需求：悬架阻尼控制自定义请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SusDmpngCtrlCustSetngReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SusDmpngCtrlCustSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SusDmpngCtrlCustSetngReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317e7fXOa505a3f19f25843c4b317e7e00">
              <SHORT-NAME>ISvGroup</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Gpgsv Data Send Group</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:GSV语句数据发送批
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SvGroup</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SvGroup</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SvGroup</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37e7c9XOa505a3f19f25843c4b37e7c800">
              <SHORT-NAME>ISwStaE2EErr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Switch_Status_E2E_Error</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:ASIL
信息安全:
有无服务标签:
发送方描述:ZXD
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾方控信号LIN E2E错误标志</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SwStaE2EErr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SwStaE2EErr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SwStaE2EErr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3719dfXOa505a3f19f25843c4b3719de00">
              <SHORT-NAME>ISyncMsgCheckSum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:AutosarCRC使用协议
1.CRC8H2F 2.Data ID:0x0
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgCheckSum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgCheckSum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgCheckSum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371a3cXOa505a3f19f25843c4b371a3b00">
              <SHORT-NAME>ISyncMsgOVS</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_OVS</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:同步溢出时间
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgOVS</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgOVS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgOVS</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371a5bXOa505a3f19f25843c4b371a5a00">
              <SHORT-NAME>ISyncMsgSGW</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_SGW</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:新增IPD与FDR时间同步信号
起始位26
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgSGW</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgSGW</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSGW</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3719feXOa505a3f19f25843c4b3719fd00">
              <SHORT-NAME>ISyncMsgSequenceCounter</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_SequenceCnt</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:顺序计数器[0，15]
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgSequenceCounter</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgSequenceCounter</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgSequenceCounter</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371a99XOa505a3f19f25843c4b371a9800">
              <SHORT-NAME>ISyncMsgTime</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_SyncTime</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:新增IPD与FDR时间同步信号
起始位39
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgTime</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>32</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgTime</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTime</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371a1dXOa505a3f19f25843c4b371a1c00">
              <SHORT-NAME>ISyncMsgTimeDomain</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_TimeDomain</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:0x1为domain ID
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgTimeDomain</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgTimeDomain</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgTimeDomain</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3719c0XOa505a3f19f25843c4b3719bf00">
              <SHORT-NAME>ISyncMsgType</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:Tsync和FUP报文的发送间隔为20ms
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgType</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgType</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgType</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371a7aXOa505a3f19f25843c4b371a7900">
              <SHORT-NAME>ISyncMsgreserved</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">IPD_SYNC_reserved</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:IPD_500ms_TimeSync_FDR_Group
功能安全:
信息安全:
有无服务标签:
发送方描述:default =0，信号预留
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SyncMsgreserved</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SyncMsgreserved</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SyncMsgreserved</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3694acXOa505a3f19f25843c4b3694ab00">
              <SHORT-NAME>ISysOpnlMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System Operational Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:操作模式
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysOpnlMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysOpnlMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysOpnlMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3694cbXOa505a3f19f25843c4b3694ca00">
              <SHORT-NAME>ISysPwrMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System Power Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:电源模式(根据UsgMd Mapping)
接收方描述:系统电源模式
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysPwrMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b371977XOa505a3f19f25843c4b37197600">
              <SHORT-NAME>ISysPwrMdCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System power mode control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group49
功能安全:
信息安全:
有无服务标签:
发送方描述:VS模式控制,电源模式控制
接收方描述:BKPCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysPwrMdCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMdCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3694eaXOa505a3f19f25843c4b3694e900">
              <SHORT-NAME>ISysPwrMdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System Power Mode Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:Y
信息安全:
有无服务标签:
发送方描述:电源模式有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:VS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysPwrMdV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysPwrMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysPwrMdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369509XOa505a3f19f25843c4b36950800">
              <SHORT-NAME>ISysVol</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System_Voltage</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:系统电压
接收方描述:Tester
ESS
PEU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:驻车能耗&amp;电源管理，ESS,EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysVol</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVol</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369528XOa505a3f19f25843c4b36952700">
              <SHORT-NAME>ISysVolMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System Voltage Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:系统电压模式
接收方描述:系统电压模式
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysVolMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369547XOa505a3f19f25843c4b36954600">
              <SHORT-NAME>ISysVolMdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System Voltage Mode Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:系统电压模式有效性
接收方描述:系统电压模式有效性
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysVolMdV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolMdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolMdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b369566XOa505a3f19f25843c4b36956500">
              <SHORT-NAME>ISysVolV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">System_Voltage_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBVC_20ms_Group03
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:系统电压有效性
接收方描述:Tester
ESS
PEU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:驻车能耗&amp;电源管理，ESS,EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SysVolV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SysVolV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SysVolV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec46aXOa505a3f19f25843c4b2ec46900">
              <SHORT-NAME>ITASSAMTqSplt_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TASSAMTqSplt_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TASSAMTqSplt_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TASSAMTqSplt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TASSAMTqSplt_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec5fdXOa505a3f19f25843c4b2ec5fc00">
              <SHORT-NAME>ITASTMTqSplt_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TASTMTqSplt_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TASTMTqSplt_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TASTMTqSplt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TASTMTqSplt_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bf89XOa505a3f19f25843c4b34bf8800">
              <SHORT-NAME>ITCM_020ms_PDU18_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_020ms_PDU18_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bfa0XOa505a3f19f25843c4b34bf9f00">
              <SHORT-NAME>ITCM_020ms_PDU18_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_020ms_PDU18_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bfb7XOa505a3f19f25843c4b34bfb600">
              <SHORT-NAME>ITCM_020ms_PDU18_Reserve01</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_020ms_PDU18_Reserve01</SHORT-LABEL>
                  <VALUE>0x7F</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve01</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bfceXOa505a3f19f25843c4b34bfcd00">
              <SHORT-NAME>ITCM_020ms_PDU18_Reserve02</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_020ms_PDU18_Reserve02</SHORT-LABEL>
                  <VALUE>0xFFFFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>24</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve02</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve02</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bfe5XOa505a3f19f25843c4b34bfe400">
              <SHORT-NAME>ITCM_020ms_PDU18_Reserve03</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_020ms_PDU18_Reserve03</SHORT-LABEL>
                  <VALUE>0xF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_020ms_PDU18_Reserve03</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve03</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b342f81XOa505a3f19f25843c4b342f8000">
              <SHORT-NAME>ITCM_025ms_Group02_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_Group02_Reserved1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b342f99XOa505a3f19f25843c4b342f9800">
              <SHORT-NAME>ITCM_025ms_Group02_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_Group02_Reserved2</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b342fb0XOa505a3f19f25843c4b342faf00">
              <SHORT-NAME>ITCM_025ms_Group02_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_Group02_Reserved3</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_Group02_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34170cXOa505a3f19f25843c4b34170b00">
              <SHORT-NAME>ITCM_025ms_PDU02_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU02_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU02_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341723XOa505a3f19f25843c4b34172200">
              <SHORT-NAME>ITCM_025ms_PDU02_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU02_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU02_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b37f78XNa505a3f19f5902a13b37f6900">
              <SHORT-NAME>ITCM_025ms_PDU05_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU05_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b37fa4XNa505a3f19f5902a13b37f9500">
              <SHORT-NAME>ITCM_025ms_PDU05_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU05_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b37fcdXNa505a3f19f5902a13b37fbe00">
              <SHORT-NAME>ITCM_025ms_PDU05_Reserve01</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU05_Reserve01</SHORT-LABEL>
                  <VALUE>0x1FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU05_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_Reserve01</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b3835bXNa505a3f19f5902a13b3834c00">
              <SHORT-NAME>ITCM_025ms_PDU20_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b38386XNa505a3f19f5902a13b3837700">
              <SHORT-NAME>ITCM_025ms_PDU20_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b383afXNa505a3f19f5902a13b383a000">
              <SHORT-NAME>ITCM_025ms_PDU20_Reserve01</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_Reserve01</SHORT-LABEL>
                  <VALUE>0xFFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve01</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve01</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b383d8XNa505a3f19f5902a13b383c900">
              <SHORT-NAME>ITCM_025ms_PDU20_Reserve02</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_Reserve02</SHORT-LABEL>
                  <VALUE>0xFFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve02</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve02</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b38401XNa505a3f19f5902a13b383f200">
              <SHORT-NAME>ITCM_025ms_PDU20_Reserve03</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_Reserve03</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve03</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve03</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b3842aXNa505a3f19f5902a13b3841b00">
              <SHORT-NAME>ITCM_025ms_PDU20_Reserve04</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCM_025ms_PDU20_Reserve04</SHORT-LABEL>
                  <VALUE>0xFFFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCM_025ms_PDU20_Reserve04</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve04</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366074XOa505a3f19f25843c4b36607300">
              <SHORT-NAME>ITCSA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traction Control System Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:TCS激活状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCSA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e2523XOa505a3f19f25843c4b2e252200">
              <SHORT-NAME>ITCSDrvrItnt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traction_Control_System_Driver_Intent</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ICB、RZCU、AMR,RZCU,LHZCU,RHZCU,ICB,EPS,FDR,IAM,ICB,ICB,IMCU,IPD,LFSDA,LHRDA,RFSDA,RHRDA,SCM,SDM,Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCSDrvrItnt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSDrvrItnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSDrvrItnt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366093XOa505a3f19f25843c4b36609200">
              <SHORT-NAME>ITCSEnbd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traction Control System Enabled</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:TCS使能状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCSEnbd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSEnbd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSEnbd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3660b2XOa505a3f19f25843c4b3660b100">
              <SHORT-NAME>ITCSOpngMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traction Control System Operating Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:TCS工作模式
接收方描述:EDR元素，牵引力控制系统,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCSOpngMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSOpngMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3660d1XOa505a3f19f25843c4b3660d000">
              <SHORT-NAME>ITCSOpngSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traction Control System Operating Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:TCS工作状态
接收方描述:EDR元素，牵引力控制系统,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCSOpngSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCSOpngSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCSOpngSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec25bXOa505a3f19f25843c4b2ec25a00">
              <SHORT-NAME>ITCUIntvSAMTq_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TCUIntvSAMTq_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCUIntvSAMTq_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUIntvSAMTq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUIntvSAMTq_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec790XOa505a3f19f25843c4b2ec78f00">
              <SHORT-NAME>ITCUIntvTMTq_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TCUIntvTMTq_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCUIntvTMTq_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUIntvTMTq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUIntvTMTq_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec21dXOa505a3f19f25843c4b2ec21c00">
              <SHORT-NAME>ITCUOpSt_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TCUOpSt_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TCUOpSt_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TCUOpSt_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCUOpSt_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e937bXOa505a3f19f25843c4b2e937a00">
              <SHORT-NAME>ITC_ExtdAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TC PTEXTDCAN Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TC_ExtdAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TC_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TC_ExtdAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e92c1XOa505a3f19f25843c4b2e92c000">
              <SHORT-NAME>ITC_PTAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TC PTCANFD Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TC_PTAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TC_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TC_PTAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b347fa6XOa505a3f19f25843c4b347fa500">
              <SHORT-NAME>ITDMAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:TDM节点有效性
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDMAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDMAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c1cdXOa505a3f19f25843c4b37c1cc00">
              <SHORT-NAME>ITDM_200ms_Group01_CRC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c1e4XOa505a3f19f25843c4b37c1e300">
              <SHORT-NAME>ITDM_200ms_Group01_RC</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3228dfXOa505a3f19f25843c4b3228de00">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved103</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved103</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved103</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3228faXOa505a3f19f25843c4b3228f900">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved111</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved111</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved111</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322915XOa505a3f19f25843c4b32291400">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved119</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved119</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved119</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322930XOa505a3f19f25843c4b32292f00">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved127</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved127</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved127</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3227d1XOa505a3f19f25843c4b3227d000">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved15</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved15</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3227ecXOa505a3f19f25843c4b3227eb00">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved27</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved27</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved27</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved27</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322807XOa505a3f19f25843c4b32280600">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved39</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved39</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved39</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322822XOa505a3f19f25843c4b32282100">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved47</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved47</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved47</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32283dXOa505a3f19f25843c4b32283c00">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved55</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved55</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved55</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322858XOa505a3f19f25843c4b32285700">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved63</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved63</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved63</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322873XOa505a3f19f25843c4b32287200">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved71</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved71</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved71</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32288eXOa505a3f19f25843c4b32288d00">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved79</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved79</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved79</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3228a9XOa505a3f19f25843c4b3228a800">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved87</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved87</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved87</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3228c4XOa505a3f19f25843c4b3228c300">
              <SHORT-NAME>ITDM_200ms_Group01_Reserved95</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_200ms_Group01_Reserved95</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_200ms_Group01_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved95</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3791acXOa505a3f19f25843c4b3791ab00">
              <SHORT-NAME>ITDM_NKI_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM SFCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NKI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NKI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3791e2XOa505a3f19f25843c4b3791e100">
              <SHORT-NAME>ITDM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_BSMtoRMS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_BSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_BSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379191XOa505a3f19f25843c4b37919000">
              <SHORT-NAME>ITDM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_NOSSta_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_NOSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_NOSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3791fdXOa505a3f19f25843c4b3791fc00">
              <SHORT-NAME>ITDM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_NOStoRMS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_NOStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_NOStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37924eXOa505a3f19f25843c4b37924d00">
              <SHORT-NAME>ITDM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_PBSMtoRMS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_PBSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_PBSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379218XOa505a3f19f25843c4b37921700">
              <SHORT-NAME>ITDM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_RMSSta_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_RMSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_RMSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379284XOa505a3f19f25843c4b37928300">
              <SHORT-NAME>ITDM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_RMStoNOS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_RMStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_RMStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379269XOa505a3f19f25843c4b37926800">
              <SHORT-NAME>ITDM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_RSStoNOS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_RSStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_RSStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3791c7XOa505a3f19f25843c4b3791c600">
              <SHORT-NAME>ITDM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_NM_RSStoRMS_SFCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NM_RSStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NM_RSStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379176XOa505a3f19f25843c4b37917500">
              <SHORT-NAME>ITDM_NOI_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM SFCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NOI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NOI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b379233XOa505a3f19f25843c4b37923200">
              <SHORT-NAME>ITDM_NWI_SFCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TDM_SFCANFD Network Wakeup Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TDM_NWI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TDM_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_NWI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eac51XOa505a3f19f25843c4b2eac5000">
              <SHORT-NAME>ITJAICAMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Jam_Assist_Integrated_Cruise_Assist_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TJAICAMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICAMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICAMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a235XOa505a3f19f25843c4b36a23400">
              <SHORT-NAME>ITJAICASysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Jam Assist Integrated Cruise Assist Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_ZONE_20ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM，AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TJAICASysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICASysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a254XOa505a3f19f25843c4b36a25300">
              <SHORT-NAME>ITJAICASysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Jam Assist Integrated Cruise Assist System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_ZONE_20ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:LCC系统状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TJAICASysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TJAICASysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TJAICASysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eac70XOa505a3f19f25843c4b2eac6f00">
              <SHORT-NAME>ITLRMdSwDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_lights_recognition_Mode_Switch_Display_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TLR开关反馈
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TLRMdSwDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMdSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMdSwDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e85d7XOa505a3f19f25843c4b2e85d600">
              <SHORT-NAME>ITLRMdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_lights_recognition_Mode_Switch_Display_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TLR开关请求
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TLRMdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eac8fXOa505a3f19f25843c4b2eac8e00">
              <SHORT-NAME>ITLRMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_lights_recognition_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TLR交通信号灯提示文言
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TLRMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eacaeXOa505a3f19f25843c4b2eacad00">
              <SHORT-NAME>ITLRSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_lights_recognition_System_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TLR功能状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TLRSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eaccdXOa505a3f19f25843c4b2eaccc00">
              <SHORT-NAME>ITLRWarning</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_lights_recognition_Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TLR交通信号灯警告提醒
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TLRWarning</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TLRWarning</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TLRWarning</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317968XOa505a3f19f25843c4b31796700">
              <SHORT-NAME>ITPMSAutoLoctnCm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire_Pressure_Monitor_System_Auto_Location_Complete</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:胎压传感器ID自定位学习状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSAutoLoctnCm</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSAutoLoctnCm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSAutoLoctnCm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34f376XOa505a3f19f25843c4b34f37500">
              <SHORT-NAME>ITPMSAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TPMS LHBDEXTDCAN Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346639XOa505a3f19f25843c4b34663800">
              <SHORT-NAME>ITPMSBtmNosRSSI</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Bottom Noise Received Signal Strength Indicator</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统底部噪声接收信号强度指示器
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSBtmNosRSSI</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSBtmNosRSSI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSBtmNosRSSI</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bc12XOa505a3f19f25843c4b34bc1100">
              <SHORT-NAME>ITPMSF</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Failed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:LHZCU_400ms_Group18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:SDM,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSF</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSF</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317797XOa505a3f19f25843c4b31779600">
              <SHORT-NAME>ITPMSIdficnLrnCm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire_Pressure_Monitor_System_Identification_Learn_Complete</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:胎压传感器ID学习状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:TPMS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSIdficnLrnCm</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSIdficnLrnCm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSIdficnLrnCm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b349560XOa505a3f19f25843c4b34955f00">
              <SHORT-NAME>ITPMSPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TPMS Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:ZXD播报负载配电通断状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34661eXOa505a3f19f25843c4b34661d00">
              <SHORT-NAME>ITPMSSnsrID</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Sensor Id</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统传感器Id
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSSnsrID</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrID</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrID</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3465e8XOa505a3f19f25843c4b3465e700">
              <SHORT-NAME>ITPMSSnsrIDLoctn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Sensor Id Location</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统传感器Id位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSSnsrIDLoctn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrIDLoctn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrIDLoctn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3466c0XOa505a3f19f25843c4b3466bf00">
              <SHORT-NAME>ITPMSSnsrRSSI</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Sensor Received Signal Strength Indicator</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统传感器接收信号强度指示器
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSSnsrRSSI</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRSSI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRSSI</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346654XOa505a3f19f25843c4b34665300">
              <SHORT-NAME>ITPMSSnsrRdoFrqcCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Sensor Radio Frequency Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统传感器射频计数器
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSSnsrRdoFrqcCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRdoFrqcCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRdoFrqcCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3466dbXOa505a3f19f25843c4b3466da00">
              <SHORT-NAME>ITPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Sensor Radio Frequency Counter Location</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统传感器射频计数器位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSSnsrRdoFrqcCtrLoctn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSSnsrRdoFrqcCtrLoctn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSSnsrRdoFrqcCtrLoctn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bc2dXOa505a3f19f25843c4b34bc2c00">
              <SHORT-NAME>ITPMSTirePrsLowIO</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Tire Pressure Low Indication On</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:LHZCU_400ms_Group18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:SDM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSTirePrsLowIO</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSTirePrsLowIO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSTirePrsLowIO</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34666fXOa505a3f19f25843c4b34666e00">
              <SHORT-NAME>ITPMSWntrMdA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire Pressure Monitor System Winter Mode Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):400.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:胎压监测系统冬季模式激活
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TPMSWntrMdA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TPMSWntrMdA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TPMSWntrMdA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ebf92XOa505a3f19f25843c4b2ebf9100">
              <SHORT-NAME>ITQRTMTqReq_N</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TQRTMTqReq_N</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TQRTMTqReq_N</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TQRTMTqReq_N</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TQRTMTqReq_N</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ebdc1XOa505a3f19f25843c4b2ebdc000">
              <SHORT-NAME>ITRCEMTqReq_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TRCEMTqReq_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TRCEMTqReq_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TRCEMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TRCEMTqReq_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec00eXOa505a3f19f25843c4b2ec00d00">
              <SHORT-NAME>ITRCTqDmdSTC_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TRCTqDmdSTC_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TRCTqDmdSTC_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TRCTqDmdSTC_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TRCTqDmdSTC_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ead0bXOa505a3f19f25843c4b2ead0a00">
              <SHORT-NAME>ITSRSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Sign Recognization Function Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR功能状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TSRSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e86eeXOa505a3f19f25843c4b2e86ed00">
              <SHORT-NAME>ITSRSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TSR_Switch_Request_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR开关请求
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TSRSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ead2aXOa505a3f19f25843c4b2ead2900">
              <SHORT-NAME>ITSRSwReqResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TSR_Switch_Request_Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR开关反馈
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TSRSwReqResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRSwReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRSwReqResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ead49XOa505a3f19f25843c4b2ead4800">
              <SHORT-NAME>ITSRTrgtBanSign</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Sign Recognization Target Ban Sign</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR禁止类标识显示
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TSRTrgtBanSign</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRTrgtBanSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRTrgtBanSign</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ead68XOa505a3f19f25843c4b2ead6700">
              <SHORT-NAME>ITSRTrgtWarnSign</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Sign Recognization Target Warning Sign</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:TSR警告类标识显示
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TSRTrgtWarnSign</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TSRTrgtWarnSign</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TSRTrgtWarnSign</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec353XOa505a3f19f25843c4b2ec35200">
              <SHORT-NAME>ITZXEMMaxTqReq_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TZXEMMaxTqReq_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TZXEMMaxTqReq_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TZXEMMaxTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TZXEMMaxTqReq_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ebf73XOa505a3f19f25843c4b2ebf7200">
              <SHORT-NAME>ITZXEMTqReq_Nm</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TZXEMTqReq_Nm</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TZXEMTqReq_Nm</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>13</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TZXEMTqReq_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TZXEMTqReq_Nm</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cd5cXOa505a3f19f25843c4b37cd5b00">
              <SHORT-NAME>ITakeKeyOutRmndr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Take Key Out Reminder</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:ZXD、IAM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TakeKeyOutRmndr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TakeKeyOutRmndr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TakeKeyOutRmndr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cdadXOa505a3f19f25843c4b37cdac00">
              <SHORT-NAME>ITakeKeyOutRmndrPersSetReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Take Key Out Reminder Personalization Setting Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ZXD
接收方描述:LHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TakeKeyOutRmndrPersSetReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TakeKeyOutRmndrPersSetReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TakeKeyOutRmndrPersSetReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ebd0XOa505a3f19f25843c4b37ebcf00">
              <SHORT-NAME>ITemSnsrHdwrFltPrst</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Temperature Sensor Hardware Fault Present</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:玻璃温度检测电路故障
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TemSnsrHdwrFltPrst</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TemSnsrHdwrFltPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TemSnsrHdwrFltPrst</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c50fXOa505a3f19f25843c4b34c50e00">
              <SHORT-NAME>ITgtParkingChosed</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target_Parking_Chosed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group13
功能安全:
信息安全:
有无服务标签:
发送方描述:ZXD
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TgtParkingChosed</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TgtParkingChosed</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TgtParkingChosed</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372313XOa505a3f19f25843c4b37231200">
              <SHORT-NAME>ITgtParkingFavorite</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Target Parking Favorite</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:泊车推荐车位ID
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TgtParkingFavorite</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TgtParkingFavorite</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TgtParkingFavorite</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3493b7XOa505a3f19f25843c4b3493b600">
              <SHORT-NAME>ITiltSnsrSetngReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tilt Sensor Setting Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:倾斜探测设置请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TiltSnsrSetngReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TiltSnsrSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TiltSnsrSetngReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376a86XOa505a3f19f25843c4b376a8500">
              <SHORT-NAME>ITimeDspFmt</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TimeDspFmt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TimeDspFmt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TimeDspFmt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375802XOa505a3f19f25843c4b37580100">
              <SHORT-NAME>ITireBlowoutPos</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire_Blowout_Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:爆胎轮位置信息
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TireBlowoutPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TireBlowoutPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TireBlowoutPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37581dXOa505a3f19f25843c4b37581c00">
              <SHORT-NAME>ITireBlowoutStabCtrlSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tire_Blowout_Stability_Control_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:RZCU_ZONE_10ms_Group64
功能安全:ASILB
信息安全:
有无服务标签:
发送方描述:爆胎稳定性控制激活状态
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TireBlowoutStabCtrlSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TireBlowoutStabCtrlSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TireBlowoutStabCtrlSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eacecXOa505a3f19f25843c4b2eaceb00">
              <SHORT-NAME>IToEPSMsgChlg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">To Electric Power Steering Message Challenge</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):0.0
Num. Of Repetition:0.0
Signal Type:UNM
备注:EPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ToEPSMsgChlg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>64</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT64</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ToEPSMsgChlg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ToEPSMsgChlg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36806bXOa505a3f19f25843c4b36806a00">
              <SHORT-NAME>ITotActuWhlToq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Total Actual Wheel Torque</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:null
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TotActuWhlToq</SHORT-LABEL>
                  <VALUE>0x7530</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TotActuWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TotActuWhlToq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36808aXOa505a3f19f25843c4b36808900">
              <SHORT-NAME>ITotActuWhlToqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Total Actual Wheel Torque Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:null
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TotActuWhlToqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TotActuWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TotActuWhlToqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec08aXOa505a3f19f25843c4b2ec08900">
              <SHORT-NAME>ITqCtrlStat_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">TqCtrlStat_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TqCtrlStat_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TqCtrlStat_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TqCtrlStat_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b38453XNa505a3f19f5902a13b3844400">
              <SHORT-NAME>ITrACCToqReqResp</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_PDU20
功能安全:
信息安全:
有无服务标签:
发送方描述:DCT变速箱发送的DCT对ACC的响应状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrACCToqReqResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrACCToqReqResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrACCToqReqResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bffcXOa505a3f19f25843c4b34bffb00">
              <SHORT-NAME>ITrAPACanclReq</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrAPACanclReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrAPACanclReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrAPACanclReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34173aXOa505a3f19f25843c4b34173900">
              <SHORT-NAME>ITrClThrmlProtnNotfn_ECM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Clutch Thermal Protection Notification</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):500.0
Signal Group:ECM_500ms_group02
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:PICM
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrClThrmlProtnNotfn_ECM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrClThrmlProtnNotfn_ECM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrClThrmlProtnNotfn_ECM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376bfdXOa505a3f19f25843c4b376bfc00">
              <SHORT-NAME>ITrCrkshftToqLd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrCrkshftToqLd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrkshftToqLd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c14XOa505a3f19f25843c4b376c1300">
              <SHORT-NAME>ITrCrkshftToqLdV</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrCrkshftToqLdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrkshftToqLdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrkshftToqLdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37674bXOa505a3f19f25843c4b37674a00">
              <SHORT-NAME>ITrCrpMdA_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrCrpMdA_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCrpMdA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrpMdA_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c2bXOa505a3f19f25843c4b376c2a00">
              <SHORT-NAME>ITrCustSetngDspCmd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrCustSetngDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrCustSetngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCustSetngDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376790XOa505a3f19f25843c4b37678f00">
              <SHORT-NAME>ITrEPBAppReq</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEPBAppReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEPBAppReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEPBAppReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c42XOa505a3f19f25843c4b376c4100">
              <SHORT-NAME>ITrEnASSOvrd</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEnASSOvrd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEnASSOvrd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEnASSOvrd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36bac6XOa505a3f19f25843c4b36bac500">
              <SHORT-NAME>ITrEngdSta</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Engaged State_Transmission Control Module</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEngdSta</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdSta</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36bae5XOa505a3f19f25843c4b36bae400">
              <SHORT-NAME>ITrEngdStaV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Engaged State Validity_Transmission Control Module</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEngdStaV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdStaV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdStaV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376779XOa505a3f19f25843c4b37677800">
              <SHORT-NAME>ITrEngdStaV_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEngdStaV_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdStaV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdStaV_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376762XOa505a3f19f25843c4b37676100">
              <SHORT-NAME>ITrEngdSta_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEngdSta_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEngdSta_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdSta_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3687dfXOa505a3f19f25843c4b3687de00">
              <SHORT-NAME>ITrEstdGear</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Estimated Gear</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,SDM,IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEstdGear</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGear</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3687c0XOa505a3f19f25843c4b3687bf00">
              <SHORT-NAME>ITrEstdGearV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Estimated Gear Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:IBS,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEstdGearV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGearV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGearV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3767beXOa505a3f19f25843c4b3767bd00">
              <SHORT-NAME>ITrEstdGearV_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEstdGearV_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGearV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGearV_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3767a7XOa505a3f19f25843c4b3767a600">
              <SHORT-NAME>ITrEstdGear_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrEstdGear_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrEstdGear_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGear_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b37ff6XNa505a3f19f5902a13b37fe700">
              <SHORT-NAME>ITrGear</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:CVT发送的挡位信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrGear</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrGear</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrGear</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b3801fXNa505a3f19f5902a13b3801000">
              <SHORT-NAME>ITrGearV</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:CVT发送的挡位信号有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrGearV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrGearV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrGearV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b38048XNa505a3f19f5902a13b3803900">
              <SHORT-NAME>ITrImmdCrkshftToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Immediate Crankshaft Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrImmdCrkshftToqReqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrImmdCrkshftToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrImmdCrkshftToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b38071XNa505a3f19f5902a13b3806200">
              <SHORT-NAME>ITrImmdCrkshftToqRespTyp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Immediate Crankshaft Torque Response Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrImmdCrkshftToqRespTyp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrImmdCrkshftToqRespTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrImmdCrkshftToqRespTyp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376ba1XOa505a3f19f25843c4b376ba000">
              <SHORT-NAME>ITrInptClStsV_ICE</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrInptClStsV_ICE</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrInptClStsV_ICE</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClStsV_ICE</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376b8aXOa505a3f19f25843c4b376b8900">
              <SHORT-NAME>ITrInptClSts_ICE</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrInptClSts_ICE</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrInptClSts_ICE</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrInptClSts_ICE</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3767d5XOa505a3f19f25843c4b3767d400">
              <SHORT-NAME>ITrIntnlSwPos</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrIntnlSwPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrIntnlSwPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrIntnlSwPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3767ecXOa505a3f19f25843c4b3767eb00">
              <SHORT-NAME>ITrIntnlSwPosV</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrIntnlSwPosV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrIntnlSwPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrIntnlSwPosV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c59XOa505a3f19f25843c4b376c5800">
              <SHORT-NAME>ITrMinVolReq</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrMinVolReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrMinVolReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrMinVolReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376f76XOa505a3f19f25843c4b376f7500">
              <SHORT-NAME>ITrPfShftPtrnSw1A</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBVC_50ms_Group11
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPfShftPtrnSw1A</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw1A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw1A</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376f8dXOa505a3f19f25843c4b376f8c00">
              <SHORT-NAME>ITrPfShftPtrnSw2A</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBVC_50ms_Group11
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPfShftPtrnSw2A</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw2A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw2A</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376fa4XOa505a3f19f25843c4b376fa300">
              <SHORT-NAME>ITrPfShftPtrnSw3A</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBVC_50ms_Group11
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPfShftPtrnSw3A</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw3A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw3A</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376fbbXOa505a3f19f25843c4b376fba00">
              <SHORT-NAME>ITrPfShftPtrnSw4A</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBVC_50ms_Group11
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPfShftPtrnSw4A</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPfShftPtrnSw4A</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPfShftPtrnSw4A</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b3809aXNa505a3f19f5902a13b3808b00">
              <SHORT-NAME>ITrPrdtdCrkshftToqIntrvnTyp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Predicted Crankshaft Torque Intervention Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPrdtdCrkshftToqIntrvnTyp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrdtdCrkshftToqIntrvnTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrdtdCrkshftToqIntrvnTyp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f5902a13b380c3XNa505a3f19f5902a13b380b400">
              <SHORT-NAME>ITrPrdtdCrkshftToqReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission Predicted Crankshaft Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_PTCAN_FrP05
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:Tester
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPrdtdCrkshftToqReqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrdtdCrkshftToqReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrdtdCrkshftToqReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376803XOa505a3f19f25843c4b37680200">
              <SHORT-NAME>ITrPrkPos</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPrkPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrkPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrkPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37681aXOa505a3f19f25843c4b37681900">
              <SHORT-NAME>ITrPrkSysF</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrPrkSysF</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrPrkSysF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrkSysF</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c70XOa505a3f19f25843c4b376c6f00">
              <SHORT-NAME>ITrRngInhSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrRngInhSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrRngInhSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrRngInhSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3687feXOa505a3f19f25843c4b3687fd00">
              <SHORT-NAME>ITrShftLvrPos</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission_Shift_Lever_Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:变速箱档位
接收方描述:null
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:账户管理，换挡控制 BPEPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrShftLvrPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36881dXOa505a3f19f25843c4b36881c00">
              <SHORT-NAME>ITrShftLvrPosV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Transmission_Shift_Lever_Position_Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RZCU_20ms_Group06
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:null
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:账户管理，换挡控制 BPEPS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrShftLvrPosV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPosV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPosV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3416deXOa505a3f19f25843c4b3416dd00">
              <SHORT-NAME>ITrShftLvrPosV_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrShftLvrPosV_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPosV_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPosV_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3416f5XOa505a3f19f25843c4b3416f400">
              <SHORT-NAME>ITrShftLvrPos_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PTCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrShftLvrPos_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftLvrPos_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPos_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376831XOa505a3f19f25843c4b37683000">
              <SHORT-NAME>ITrShftPtrnASts_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrShftPtrnASts_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrShftPtrnASts_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftPtrnASts_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376848XOa505a3f19f25843c4b37684700">
              <SHORT-NAME>ITrTapUpTapDwnMdSts_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrTapUpTapDwnMdSts_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrTapUpTapDwnMdSts_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrTapUpTapDwnMdSts_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37685fXOa505a3f19f25843c4b37685e00">
              <SHORT-NAME>ITrTrgtShftLvrPos</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:TCM_025ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrTrgtShftLvrPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrTrgtShftLvrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrTrgtShftLvrPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376c87XOa505a3f19f25843c4b376c8600">
              <SHORT-NAME>ITrWrnngDsp</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ECM_25ms_Group36
功能安全:ASILC
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrWrnngDsp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrWrnngDsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrWrnngDsp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bbb6XOa505a3f19f25843c4b34bbb500">
              <SHORT-NAME>ITrdRowLOccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Third Row Left Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:第三排座椅占位信号，安全带提醒功能
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdRowLOccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowLOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdRowLOccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bbd1XOa505a3f19f25843c4b34bbd000">
              <SHORT-NAME>ITrdRowMOccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Third Row Middle Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:第三排座椅占位信号，安全带提醒功能
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdRowMOccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowMOccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdRowMOccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bbecXOa505a3f19f25843c4b34bbeb00">
              <SHORT-NAME>ITrdRowROccupntSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Third Row Right Occupant Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:第三排座椅占位信号，安全带提醒功能
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdRowROccupntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdRowROccupntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdRowROccupntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cc31XOa505a3f19f25843c4b37cc3000">
              <SHORT-NAME>ITrdtnKeyBtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tradition Key Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:IPD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdtnKeyBtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnKeyBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnKeyBtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cc9fXOa505a3f19f25843c4b37cc9e00">
              <SHORT-NAME>ITrdtnSmrtKyFindCarSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tradition Smart Key Find Car Switch Press Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:IPD、ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdtnSmrtKyFindCarSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyFindCarSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyFindCarSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34a1a6XOa505a3f19f25843c4b34a1a500">
              <SHORT-NAME>ITrdtnSmrtKyLckSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">tradition smart key lock switch status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:QM
信息安全:
有无服务标签:
发送方描述:RF芯片的实体钥匙闭锁按键状态信号，用于钥匙控窗功能
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdtnSmrtKyLckSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyLckSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyLckSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37cc4cXOa505a3f19f25843c4b37cc4b00">
              <SHORT-NAME>ITrdtnSmrtKyLdspcSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Tradition Smart Key Loadspace Switch Press Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:IPD、ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdtnSmrtKyLdspcSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyLdspcSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyLdspcSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34a18bXOa505a3f19f25843c4b34a18a00">
              <SHORT-NAME>ITrdtnSmrtKyUnlckSwSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">tradition smart key unlock switch status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:QM
信息安全:
有无服务标签:
发送方描述:RF芯片的实体钥匙 解锁按键状态信号，用于钥匙控窗功能
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrdtnSmrtKyUnlckSwSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrdtnSmrtKyUnlckSwSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrdtnSmrtKyUnlckSwSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3243d0XOa505a3f19f25843c4b3243cf00">
              <SHORT-NAME>ITrfGreenLghtActn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic Green Light Attention</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ZXD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfGreenLghtActn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfGreenLghtActn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfGreenLghtActn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323833XOa505a3f19f25843c4b32383200">
              <SHORT-NAME>ITrfcForbidDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Forbidden_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcForbidDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcForbidDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcForbidDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323852XOa505a3f19f25843c4b32385100">
              <SHORT-NAME>ITrfcInfoSignDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Information_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>TrfcInfoSignDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/TrfcInfoSignDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrfcInfoSignDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323624XOa505a3f19f25843c4b32362300">
              <SHORT-NAME>ITrfcJamRngNav</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Traffic_Jam_Range_Navigation</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:IPD
