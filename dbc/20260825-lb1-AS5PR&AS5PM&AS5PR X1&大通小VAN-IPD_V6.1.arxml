                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>912</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3246d00">
                          <SHORT-NAME>IAM_CONNCANFD_100ms_FrP40</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_100ms_FrP40_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_100ms_FrP40</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU40</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>874</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1f4300">
                          <SHORT-NAME>IAM_CONNCANFD_20ms_FrP32</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_20ms_FrP32_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_20ms_FrP32</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_20ms_PDU32</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>336</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c184900">
                          <SHORT-NAME>IAM_CONNCANFD_Event_FrS04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCANFD_Event_FrS04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCANFD_Event_FrS04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_Sporadic_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>89</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c178b00">
                          <SHORT-NAME>IAM_CONNCAN_100ms_FrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCAN_100ms_FrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCAN_100ms_FrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1000</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3380000">
                          <SHORT-NAME>IAM_CONNCAN_100ms_FrP18</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCAN_100ms_FrP18_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCAN_100ms_FrP18</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU18</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>811</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1ed100">
                          <SHORT-NAME>IAM_CONNCAN_100ms_FrS21</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_CONNCAN_100ms_FrS21_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_CONNCAN_100ms_FrS21</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_100ms_PDU21</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1358</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e33bcd00">
                          <SHORT-NAME>IAM_RHBKBCANFD_100ms_FrP57</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_RHBKBCANFD_100ms_FrP57_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_RHBKBCANFD_100ms_FrP57</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU57</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>810</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3240900">
                          <SHORT-NAME>IAM_RZCUCANFD_100ms_FrP35</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_RZCUCANFD_100ms_FrP35_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_RZCUCANFD_100ms_FrP35</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU35</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>793</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e324d700">
                          <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_CONNCANFD_100ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_ZONE_CONNCANFD_100ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>773</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3388100">
                          <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP56</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IAM_ZONE_CONNCANFD_100ms_FrP56_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IAM_ZONE_CONNCANFD_100ms_FrP56</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IAM_ZONE_100ms_PDU56</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>974</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c115d00">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP27</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP27_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP27</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU27</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>348</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f4453c000">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP29_NoSecOC</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP29_NoSecOC_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP29_NoSecOC</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU29</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>917</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2eb100">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP34</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP34_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP34</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU34</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>859</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1b6700">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP36</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP36_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP36</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU36</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>895</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c22f300">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP37</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP37_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP37</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU37</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>820</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2ed700">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP38</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP38_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP38</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU38</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1105</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1b8d00">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP39</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP39_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP39</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU39</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1106</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c22a700">
                          <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP44</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_100ms_FrP44_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_100ms_FrP44</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU44</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>151</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c22cd00">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_20ms_FrP07_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP07</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU07</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>382</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c23d700">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP09</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_20ms_FrP09_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP09</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU09</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>385</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c111100">
                          <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_20ms_FrP46_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_20ms_FrP46</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU46</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>343</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c27b300">
                          <SHORT-NAME>ICBAD_BKPCANFD_50ms_FrP17</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_BKPCANFD_50ms_FrP17_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_BKPCANFD_50ms_FrP17</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_50ms_PDU17</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>736</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2b1d00">
                          <SHORT-NAME>ICBAD_CHCANFD_100ms_FrP25</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_CHCANFD_100ms_FrP25_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_100ms_FrP25</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU25</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>893</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c300700">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP08</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_CHCANFD_20ms_FrP08_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP08</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU08</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>314</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a03148f4f31c45e00">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_CHCANFD_20ms_FrP13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>360</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c113700">
                          <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP48</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_CHCANFD_20ms_FrP48_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_CHCANFD_20ms_FrP48</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU48</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>474</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f6049f81f2578400">
                          <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP05</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_RZCUCANFD_20ms_FrP05_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_RZCUCANFD_20ms_FrP05</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU05</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>351</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2ceb00">
                          <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_RZCUCANFD_20ms_FrP12_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_RZCUCANFD_20ms_FrP12</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_20ms_PDU12</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>424</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1bb300">
                          <SHORT-NAME>ICBAD_SecOC_ComKeyResp</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_SecOC_ComKeyResp_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_SecOC_ComKeyResp</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_SecOCComKeyResp_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>50</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1bd900">
                          <SHORT-NAME>ICBAD_SecOC_Log</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_SecOC_Log_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_SecOC_Log</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_SecOCLog_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>178</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c204d00">
                          <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBAD_ZONE_CHCANFD_20ms_FrP13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBAD_ZONE_CHCANFD_20ms_FrP13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_ZONE_20ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>81</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1c7100">
                          <SHORT-NAME>ICBVC_BKPCANFD_1000ms_FrP50</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_1000ms_FrP50_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_1000ms_FrP50</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_1000ms_PDU50</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1282</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e32d3600">
                          <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_100ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_100ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>66</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c118300">
                          <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP17</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_100ms_FrP17_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_100ms_FrP17</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU17</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>871</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1bff00">
                          <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP25</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_100ms_FrP25_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_100ms_FrP25</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU25</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>906</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1c2500">
                          <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP31</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_100ms_FrP31_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_100ms_FrP31</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU31</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1104</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c11a900">
                          <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP35</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_100ms_FrP35_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_100ms_FrP35</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU35</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>832</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e3284a00">
                          <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP11</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_50ms_FrP11_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_50ms_FrP11</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_PDU11</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>482</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c271b00">
                          <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_50ms_FrP13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_50ms_FrP13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1010</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f44258200">
                          <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP55</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_50ms_FrP55_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_50ms_FrP55</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_PDU55</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>591</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1cbd00">
                          <SHORT-NAME>ICBVC_BKPCANFD_Event_FrS138</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_BKPCANFD_Event_FrS138_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_BKPCANFD_Event_FrS138</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_Sporadic_PDU138</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>728</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c255300">
                          <SHORT-NAME>ICBVC_FOTASts_100ms_FrP47</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_FOTASts_100ms_FrP47_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_FOTASts_100ms_FrP47</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU47</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>790</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1fdb00">
                          <SHORT-NAME>ICBVC_INFOCANFD_250ms_FrP52</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_INFOCANFD_250ms_FrP52_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_INFOCANFD_250ms_FrP52</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_250ms_PDU52</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1008</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2d9300">
                          <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP27</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_100ms_FrP27_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_100ms_FrP27</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU27</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>922</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2efd00">
                          <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP48</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_100ms_FrP48_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_100ms_FrP48</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU48</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>795</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c11cf00">
                          <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP80</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_100ms_FrP80_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_100ms_FrP80</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU80</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>907</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c202700">
                          <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP50</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_200ms_FrP50_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_200ms_FrP50</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_PDU50</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1345</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2bef00">
                          <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP79</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_200ms_FrP79_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_200ms_FrP79</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_200ms_PDU79</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1151</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c200100">
                          <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP00</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_20ms_FrP00_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_20ms_FrP00</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_PDU00</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>361</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c28ff00">
                          <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_RZCUCANFD_20ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_RZCUCANFD_20ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_20ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>497</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1c9700">
                          <SHORT-NAME>ICBVC_SecOC_ComKeyReq</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_SecOC_ComKeyReq_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICBVC_SecOC_ComKeyReq</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_SecOCComKeyReq_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>60</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a03148f4f31ca7e00">
                          <SHORT-NAME>ICBVC_SecOC_SyncMsg</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICBVC_SecOC_SyncMsg_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/synthesized_ICBVC_SecOC_SyncMsg_BKPCANFD</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/SecuredIPdu_ICC_SecOC_SyncMsg</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1391</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c26a900">
                          <SHORT-NAME>ICB_BKBCANFD_100ms_FrP146</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKBCANFD_100ms_FrP146_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKBCANFD_100ms_FrP146</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_100ms_PDU146</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>815</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c134b00">
                          <SHORT-NAME>ICB_BKBCANFD_100ms_FrP147</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKBCANFD_100ms_FrP147_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKBCANFD_100ms_FrP147</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_100ms_PDU147</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>913</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1b1b00">
                          <SHORT-NAME>ICB_BKBCANFD_100ms_FrP221</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKBCANFD_100ms_FrP221_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKBCANFD_100ms_FrP221</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_100ms_PDU221</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>902</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2d6900">
                          <SHORT-NAME>ICB_BKPCANFD_100ms_FrP159</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKPCANFD_100ms_FrP159_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKPCANFD_100ms_FrP159</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_100ms_PDU159</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>955</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1af500">
                          <SHORT-NAME>ICB_BKPCANFD_100ms_FrP82</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKPCANFD_100ms_FrP82_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKPCANFD_100ms_FrP82</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_100ms_PDU82</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>746</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c23fd00">
                          <SHORT-NAME>ICB_BKPCANFD_500ms_FrP229</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKPCANFD_500ms_FrP229_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKPCANFD_500ms_FrP229</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_500ms_PDU229</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1297</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2f4900">
                          <SHORT-NAME>ICB_BKPCANFD_50ms_FrP158</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_BKPCANFD_50ms_FrP158_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_BKPCANFD_50ms_FrP158</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_50ms_PDU158</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>368</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1b4100">
                          <SHORT-NAME>ICB_CONNCANFD_Event_FrS67</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_CONNCANFD_Event_FrS67_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_CONNCANFD_Event_FrS67</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_Sporadic_PDU67</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1389</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c137100">
                          <SHORT-NAME>ICB_ZONE_BDCAN_100ms_FrP00</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ICB_ZONE_BDCAN_100ms_FrP00_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ICB_ZONE_BDCAN_100ms_FrP00</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICB_ZONE_100ms_PDU00</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1111</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2f9500">
                          <SHORT-NAME>IMM_BKPCANFD_50ms_FrP02</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_BKPCANFD_50ms_FrP02_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IMM_BKPCANFD_50ms_FrP02</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_PDU02</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>527</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2fbb00">
                          <SHORT-NAME>IMM_BKPCANFD_50ms_FrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_BKPCANFD_50ms_FrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IMM_BKPCANFD_50ms_FrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IMM_50ms_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>657</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2a2500">
                          <SHORT-NAME>IMM_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IMM_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IMM_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_IMM</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1237</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2af300">
                          <SHORT-NAME>IPD_BKBCANFD_EvtInfo</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKBCANFD_EvtInfo_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKBCANFD_EvtInfo</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_BKBCANFD_EvtInfo1</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1767</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1d7b00">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP124</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP124_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP124</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU124</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>712</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1da100">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP127</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP127_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP127</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU127</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>710</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1dc700">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP128</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP128_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP128</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU128</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>706</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c307900">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP35</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP35_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP35</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU35</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>807</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2dbd00">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP50</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP50_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP50</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU50</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>765</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1d2f00">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP58</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP58_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP58</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU58</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>844</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1d5500">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_FrP61</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_FrP61_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_FrP61</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU61</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>755</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2b7100">
                          <SHORT-NAME>IPD_BKPCANFD_100ms_P31</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_100ms_P31_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_100ms_P31</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBAD_100ms_PDU31</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>774</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1ce300">
                          <SHORT-NAME>IPD_BKPCANFD_10ms_FrP59</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_10ms_FrP59_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_10ms_FrP59</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_10ms_PDU59</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>208</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c225b00">
                          <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_20ms_FrP43_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_20ms_FrP43</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_PDU43</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>486</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c305300">
                          <SHORT-NAME>IPD_BKPCANFD_20ms_FrP60</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_20ms_FrP60_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_20ms_FrP60</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_20ms_PDU60</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>337</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1f6900">
                          <SHORT-NAME>IPD_BKPCANFD_50ms_FrP14</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_50ms_FrP14_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_50ms_FrP14</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_PDU14</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>720</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN20000011a02779c9f444c0200">
                          <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_50ms_FrP49_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_50ms_FrP49</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_50ms_PDU49</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>733</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c155100">
                          <SHORT-NAME>IPD_BKPCANFD_Event_FrS01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_Event_FrS01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_Event_FrS01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_Sporadic_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1143</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1e1300">
                          <SHORT-NAME>IPD_BKPCANFD_Event_FrS13</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_Event_FrS13_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_Event_FrS13</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_Sporadic_PDU13</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1399</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1e3900">
                          <SHORT-NAME>IPD_BKPCANFD_Event_FrS35</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_Event_FrS35_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_Event_FrS35</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_Sporadic_PDU35</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1526</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c13eb00">
                          <SHORT-NAME>IPD_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_IPD</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1202</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1ded00">
                          <SHORT-NAME>IPD_CHCANFD_100ms_FrP130</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_CHCANFD_100ms_FrP130_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_CHCANFD_100ms_FrP130</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU130</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>705</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c11f500">
                          <SHORT-NAME>IPD_PTCANFD_100ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_PTCANFD_100ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_PTCANFD_100ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>982</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1d0900">
                          <SHORT-NAME>IPD_PTCANFD_100ms_FrP16</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/IPD_PTCANFD_100ms_FrP16_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/IPD_PTCANFD_100ms_FrP16</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/IPD_100ms_PDU16</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>960</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c207300">
                          <SHORT-NAME>LFSDA_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LFSDA_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LFSDA_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_LFSDA</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1231</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c20a100">
                          <SHORT-NAME>LHRDA_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHRDA_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHRDA_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_LHRDA</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1229</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c236500">
                          <SHORT-NAME>LHZCU_BKBCANFD_100ms_FrP30</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_100ms_FrP30_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_100ms_FrP30</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_PDU30</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>995</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1fb500">
                          <SHORT-NAME>LHZCU_BKBCANFD_10ms_FrP32</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_10ms_FrP32_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_10ms_FrP32</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_PDU32</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>181</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c244900">
                          <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_400ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_400ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_400ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1149</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c265d00">
                          <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_400ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_400ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_400ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1148</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c268300">
                          <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP24</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_50ms_FrP24_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_50ms_FrP24</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU24</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>638</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c126700">
                          <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP34</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_50ms_FrP34_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_50ms_FrP34</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU34</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>745</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2c6d00">
                          <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP58</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_BKBCANFD_50ms_FrP58_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_BKBCANFD_50ms_FrP58</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU58</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>640</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c12d900">
                          <SHORT-NAME>LHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_ICBVC_LHBKBCANFD_50ms_FrP14_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_ICBVC_50ms_PDU14</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>513</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2de700">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP14</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_100ms_FrP14_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_100ms_FrP14</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_PDU14</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>800</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c128d00">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP15</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_100ms_FrP15_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_100ms_FrP15</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_PDU15</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>905</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c26cf00">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP16</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_100ms_FrP16_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_100ms_FrP16</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_PDU16</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>783</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c12b300">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP22</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_100ms_FrP22_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_100ms_FrP22</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_100ms_PDU22</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>896</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2e8b00">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_10ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_10ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_10ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_10ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>157</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c157700">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_20ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_20ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_20ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_20ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>299</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c121b00">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_50ms_FrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_50ms_FrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>566</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c124100">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP06</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_50ms_FrP06_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_50ms_FrP06</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU06</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>652</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1ef700">
                          <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP08</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/LHZCU_LHBKBCANFD_50ms_FrP08_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/LHZCU_LHBKBCANFD_50ms_FrP08</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/LHZCU_50ms_PDU08</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>547</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c238b00">
                          <SHORT-NAME>RFSDA_BKPCANFD_100ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RFSDA_BKPCANFD_100ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RFSDA_BKPCANFD_100ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_100ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>994</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c228100">
                          <SHORT-NAME>RFSDA_BKPCANFD_20ms_FrP02</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RFSDA_BKPCANFD_20ms_FrP02_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RFSDA_BKPCANFD_20ms_FrP02</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RFSDA_20ms_PDU02</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>484</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c20cf00">
                          <SHORT-NAME>RFSDA_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RFSDA_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RFSDA_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_RFSDA</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1230</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c242300">
                          <SHORT-NAME>RHRDA_BKPCANFD_50ms_FrP04</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHRDA_BKPCANFD_50ms_FrP04_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHRDA_BKPCANFD_50ms_FrP04</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHRDA_50ms_PDU04</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>725</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c20fd00">
                          <SHORT-NAME>RHRDA_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHRDA_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHRDA_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_RHRDA</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1228</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2e1100">
                          <SHORT-NAME>RHZCU_BDCAN_100ms_FrP06</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_BDCAN_100ms_FrP06_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_BDCAN_100ms_FrP06</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_PDU06</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>936</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1eab00">
                          <SHORT-NAME>RHZCU_BKBCANFD_50ms_FrP27</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_BKBCANFD_50ms_FrP27_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_BKBCANFD_50ms_FrP27</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_PDU27</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>544</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c132500">
                          <SHORT-NAME>RHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_ICBVC_LHBKBCANFD_50ms_FrP14_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_ICBVC_50ms_PDU14</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>514</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2e6500">
                          <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP10</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_RHBKBCANFD_100ms_FrP10_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_RHBKBCANFD_100ms_FrP10</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_PDU10</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>829</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c2e3b00">
                          <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP15</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_RHBKBCANFD_100ms_FrP15_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_RHBKBCANFD_100ms_FrP15</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_PDU15</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>857</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c23b100">
                          <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP20</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_RHBKBCANFD_100ms_FrP20_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_RHBKBCANFD_100ms_FrP20</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_100ms_PDU20</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>943</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1e8500">
                          <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP01</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_RHBKBCANFD_50ms_FrP01_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_RHBKBCANFD_50ms_FrP01</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_PDU01</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>649</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c12ff00">
                          <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP03</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RHZCU_RHBKBCANFD_50ms_FrP03_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RHZCU_RHBKBCANFD_50ms_FrP03</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RHZCU_50ms_PDU03</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>940</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c233f00">
                          <SHORT-NAME>RZCU_LHBKBCANFD_50ms_FrP37</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/RZCU_LHBKBCANFD_50ms_FrP37_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/RZCU_LHBKBCANFD_50ms_FrP37</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/RZCU_50ms_PDU37</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>564</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c25c500">
                          <SHORT-NAME>TPMS_LHBDEXTDCAN_400ms_FrP06</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/TPMS_LHBDEXTDCAN_400ms_FrP06_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/TPMS_LHBDEXTDCAN_400ms_FrP06</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/TPMS_400ms_PDU06</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1142</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c25eb00">
                          <SHORT-NAME>Tester_ECM_SFCANFD_10ms_FrP20</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/Tester_ECM_SFCANFD_10ms_FrP20_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/Tester_ECM_SFCANFD_10ms_FrP20</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/Teter_ECM_10ms_PDU20</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>210</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c1c4b00">
                          <SHORT-NAME>ZXD_BKBCANFD_100ms_FrP257</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_BKBCANFD_100ms_FrP257_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ZXD_BKBCANFD_100ms_FrP257</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ICBVC_100ms_PDU257</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>805</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c16cd00">
                          <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP76</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_BKPCANFD_100ms_FrP76_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ZXD_BKPCANFD_100ms_FrP76</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ZXD_100ms_PDU76</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>711</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xN200000119f4464397e339e400">
                          <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP77</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_BKPCANFD_100ms_FrP77_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ZXD_BKPCANFD_100ms_FrP77</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/ZXD_100ms_PDU77</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>707</IDENTIFIER>
                        </CAN-FRAME-TRIGGERING>
                        <CAN-FRAME-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c139700">
                          <SHORT-NAME>ZXD_BKPCANFD_NM</SHORT-NAME>
                          <FRAME-PORT-REFS>
                            <FRAME-PORT-REF DEST="FRAME-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ZXD_BKPCANFD_NM_IPD</FRAME-PORT-REF>
                          </FRAME-PORT-REFS>
                          <FRAME-REF DEST="CAN-FRAME">/Communication/Frames/ZXD_BKPCANFD_NM</FRAME-REF>
                          <PDU-TRIGGERINGS>
                            <PDU-TRIGGERING-REF-CONDITIONAL>
                              <PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/BKPCANFD/BKPCANFD/NmPDU_BKPCANFD_ZXD</PDU-TRIGGERING-REF>
                            </PDU-TRIGGERING-REF-CONDITIONAL>
                          </PDU-TRIGGERINGS>
                          <CAN-ADDRESSING-MODE>STANDARD</CAN-ADDRESSING-MODE>
                          <CAN-FRAME-RX-BEHAVIOR>CAN-FD</CAN-FRAME-RX-BEHAVIOR>
                          <CAN-FRAME-TX-BEHAVIOR>CAN-FD</CAN-FRAME-TX-BEHAVIOR>
                          <IDENTIFIER>1216</IDENTIFIER>
                          <RX-IDENTIFIER-RANGE>
                            <LOWER-CAN-ID>1152</LOWER-CAN-ID>
                            <UPPER-CAN-ID>1279</UPPER-CAN-ID>
                          </RX-IDENTIFIER-RANGE>
                        </CAN-FRAME-TRIGGERING>
                      </FRAME-TRIGGERINGS>
                      <I-SIGNAL-TRIGGERINGS>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c084b00">
                          <SHORT-NAME>ACAmbtTemMsk_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACAmbtTemMsk_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTemMsk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c085d00">
                          <SHORT-NAME>ACAmbtTemV_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACAmbtTemV_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c083900">
                          <SHORT-NAME>ACAmbtTem_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACAmbtTem_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becc100">
                          <SHORT-NAME>ACCAccReqSts_CH</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCAccReqSts_CH_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqSts_CH</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bddf300">
                          <SHORT-NAME>ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becd000">
                          <SHORT-NAME>ACCAccReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCAccReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d3300">
                          <SHORT-NAME>ACCConfmSw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCConfmSw_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCConfmSw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a9800">
                          <SHORT-NAME>ACCConfmSwReq_ACCConfmSwReq_ACCConfmSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCConfmSwReq_ACCConfmSwReq_ACCConfmSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCConfmSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9dfd00">
                          <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCCurveSpdSw_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCCurveSpdSw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a7a00">
                          <SHORT-NAME>ACCCurveSpdSwReq_ACCCurveSpdSwReq_ACCCurveSpdSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCCurveSpdSwReq_ACCCurveSpdSwReq_ACCCurveSpdSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCCurveSpdSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba27d00">
                          <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba26e00">
                          <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1Id_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Id</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba06c00">
                          <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1LatRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LatRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba25f00">
                          <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1LongtRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LongtRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba10800">
                          <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1LongtRltvSpd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1LongtRltvSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba1d300">
                          <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1Risk_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Risk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba01f00">
                          <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1SyncCtr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1SyncCtr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0aa00">
                          <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj1Typ_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj1Typ</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba0e900">
                          <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ff000">
                          <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2Id_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Id</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9dbe00">
                          <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2LatRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LatRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba1b400">
                          <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2LongtRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LongtRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9fb200">
                          <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2LongtRltvSpd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2LongtRltvSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d4200">
                          <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2Risk_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Risk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e0c00">
                          <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2SyncCtr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2SyncCtr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e1b00">
                          <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj2Typ_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj2Typ</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f9300">
                          <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3ExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3ExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba11700">
                          <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3Id_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Id</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9eb800">
                          <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3LatRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LatRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e2a00">
                          <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3LongtRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LongtRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f5400">
                          <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3LongtRltvSpd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3LongtRltvSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba1a500">
                          <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3Risk_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Risk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ca500">
                          <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3SyncCtr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3SyncCtr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba2dc00">
                          <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObj3Typ_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObj3Typ</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa4700">
                          <SHORT-NAME>ACCDetObjDistLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjDistLvl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjDistLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc30a00">
                          <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjExistPrblty_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjExistPrblty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfea500">
                          <SHORT-NAME>ACCDetObjHdngAng_ACCDetObjHdngAng_ACCDetObjHdngAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjHdngAng_ACCDetObjHdngAng_ACCDetObjHdngAng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjHdngAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2dd00">
                          <SHORT-NAME>ACCDetObjId</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjId_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjId</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2ec00">
                          <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjLatRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLatRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baeee00">
                          <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjLongtRltvDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLongtRltvDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baedf00">
                          <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjLongtRltvSpd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjLongtRltvSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ed700">
                          <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjRisk_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjRisk</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc31900">
                          <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjSyncCtr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjSyncCtr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc2fb00">
                          <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDetObjTyp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa5800">
                          <SHORT-NAME>ACCDrvrSelTrgtSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDrvrSelTrgtSpd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDrvrSelTrgtSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f3a1b413231e0100">
                          <SHORT-NAME>ACCDrvrTkovReq_ACCDrvrTkovReq_ACCDrvrTkovReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCDrvrTkovReq_ACCDrvrTkovReq_ACCDrvrTkovReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDrvrTkovReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa6900">
                          <SHORT-NAME>ACCGoNotfr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCGoNotfr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoNotfr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becdf00">
                          <SHORT-NAME>ACCGoReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCGoReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa7a00">
                          <SHORT-NAME>ACCMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfeb500">
                          <SHORT-NAME>ACCObjDet_ACCObjDet_ACCObjDet</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCObjDet_ACCObjDet_ACCObjDet_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCObjDet</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becee00">
                          <SHORT-NAME>ACCSdslReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSdslReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSdslReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa8b00">
                          <SHORT-NAME>ACCSeldTrgtDistLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSeldTrgtDistLvl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSeldTrgtDistLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9f0600">
                          <SHORT-NAME>ACCSpdLimtSw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSpdLimtSw_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSpdLimtSw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b99f300">
                          <SHORT-NAME>ACCSpdLimtSwReq_ACCSpdLimtSwReq_ACCSpdLimtSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSpdLimtSwReq_ACCSpdLimtSwReq_ACCSpdLimtSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSpdLimtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba02e00">
                          <SHORT-NAME>ACCStsSw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCStsSw_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCStsSw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b99c600">
                          <SHORT-NAME>ACCStsSwReq_ACCStsSwReq_ACCStsSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCStsSwReq_ACCStsSwReq_ACCStsSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCStsSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3becfd00">
                          <SHORT-NAME>ACCSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bde0200">
                          <SHORT-NAME>ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts_SCS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed0c00">
                          <SHORT-NAME>ACCSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa9c00">
                          <SHORT-NAME>ACCTJAMdSwDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCTJAMdSwDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ac500">
                          <SHORT-NAME>ACCTJAMdSwReq_ACCTJAMdSwReq_ACCTJAMdSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCTJAMdSwReq_ACCTJAMdSwReq_ACCTJAMdSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1b300">
                          <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd1c200">
                          <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfaad00">
                          <SHORT-NAME>ACCTotWhlToqReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCTotWhlToqReqSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfabe00">
                          <SHORT-NAME>ACCTotWhlToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACCTotWhlToqReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c086f00">
                          <SHORT-NAME>ACComprActuPwr_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ACComprActuPwr_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACComprActuPwr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a2f00">
                          <SHORT-NAME>ADAudioSWReq_ADAudioSWReq_ADAudioSWReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ADAudioSWReq_ADAudioSWReq_ADAudioSWReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADAudioSWReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba21100">
                          <SHORT-NAME>ADAudioSWSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ADAudioSWSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADAudioSWSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c08df00">
                          <SHORT-NAME>ADS_ISAMsgReq_ADS_ISAMsgReq_ADS_ISAMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ADS_ISAMsgReq_ADS_ISAMsgReq_ADS_ISAMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISAMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c08ef00">
                          <SHORT-NAME>ADS_ISASysFltSts_ADS_ISASysFltSts_ADS_ISASysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ADS_ISASysFltSts_ADS_ISASysFltSts_ADS_ISASysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISASysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c08bf00">
                          <SHORT-NAME>ADS_ISASysSts_ADS_ISASysSts_ADS_ISASysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ADS_ISASysSts_ADS_ISASysSts_ADS_ISASysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_ISASysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bee9200">
                          <SHORT-NAME>AEBBrkJerkLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBBrkJerkLvlReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBBrkJerkLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beea100">
                          <SHORT-NAME>AEBDclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdec500">
                          <SHORT-NAME>AEBDclReqSts_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqSts_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bee8300">
                          <SHORT-NAME>AEBDclReqToqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqToqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bded400">
                          <SHORT-NAME>AEBDclReqToqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqToqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beeb000">
                          <SHORT-NAME>AEBDclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdee300">
                          <SHORT-NAME>AEBDclReqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDclReqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9e7900">
                          <SHORT-NAME>AEBDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beebf00">
                          <SHORT-NAME>AEBHydBrkAstLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBHydBrkAstLvlReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBHydBrkAstLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9fd100">
                          <SHORT-NAME>AEBMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beece00">
                          <SHORT-NAME>AEBPrflReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBPrflReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBPrflReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9ae300">
                          <SHORT-NAME>AEBSwReq_AEBSwReq_AEBSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBSwReq_AEBSwReq_AEBSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beedd00">
                          <SHORT-NAME>AEBSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beeec00">
                          <SHORT-NAME>AEBSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AEBSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbe7800">
                          <SHORT-NAME>AIParkngDsp_AIParkngDsp_AIParkngDsp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngDsp_AIParkngDsp_AIParkngDsp_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngDsp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd5e800">
                          <SHORT-NAME>AIParkngEPAMdsts_AIParkngEPAMdsts_AIParkngEPAMdsts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngEPAMdsts_AIParkngEPAMdsts_AIParkngEPAMdsts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngEPAMdsts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd6e700">
                          <SHORT-NAME>AIParkngEPAMdsw_AIParkngEPAMdsw_AIParkngEPAMdsw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngEPAMdsw_AIParkngEPAMdsw_AIParkngEPAMdsw_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngEPAMdsw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc28300">
                          <SHORT-NAME>AIParkngReqICB_AIParkngReqICB_AIParkngReqICB</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngReqICB_AIParkngReqICB_AIParkngReqICB_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngReqICB</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baefd00">
                          <SHORT-NAME>AIParkngReq_AIParkngReq_AIParkngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngReq_AIParkngReq_AIParkngReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bafb100">
                          <SHORT-NAME>AIParkngReq_ZXD_AIParkngReq_ZXD_AIParkngReq_ZXD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngReq_ZXD_AIParkngReq_ZXD_AIParkngReq_ZXD_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngReq_ZXD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd54e00">
                          <SHORT-NAME>AIParkngRespICB_AIParkngRespICB_AIParkngRespICB</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngRespICB_AIParkngRespICB_AIParkngRespICB_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngRespICB</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf59400">
                          <SHORT-NAME>AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_AIParkngSSPLotSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSSPLotSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf71700">
                          <SHORT-NAME>AIParkngSSPLotSw_AIParkngSSPLotSw_AIParkngSSPLotSw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngSSPLotSw_AIParkngSSPLotSw_AIParkngSSPLotSw_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSSPLotSw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb8f300">
                          <SHORT-NAME>AIParkngSpcID_AIParkngSpcID_AIParkngSpcID</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngSpcID_AIParkngSpcID_AIParkngSpcID_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSpcID</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb9a700">
                          <SHORT-NAME>AIParkngSpdsw_AIParkngSpdsw_AIParkngSpdsw</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngSpdsw_AIParkngSpdsw_AIParkngSpdsw_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSpdsw</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8b2fe00">
                          <SHORT-NAME>AIParkngSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIParkngSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc3d00">
                          <SHORT-NAME>AIPilotIntervQuit_AIPilotIntervQuit_AIPilotIntervQuit</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIPilotIntervQuit_AIPilotIntervQuit_AIPilotIntervQuit_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPilotIntervQuit</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed1b00">
                          <SHORT-NAME>AIPkgAPASCSAcclReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AIPkgAPASCSAcclReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPkgAPASCSAcclReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdcd400">
                          <SHORT-NAME>ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdce400">
                          <SHORT-NAME>ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf0bd00">
                          <SHORT-NAME>AMRPrtensonReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AMRPrtensonReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAMRPrtensonReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124ab000">
                          <SHORT-NAME>APACmdEPSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APACmdEPSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACmdEPSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f43f00">
                          <SHORT-NAME>APACrpSpdReqVal_IPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APACrpSpdReqVal_IPD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACrpSpdReqVal_IPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed2a00">
                          <SHORT-NAME>APAEPBOPReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAEPBOPReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed3900">
                          <SHORT-NAME>APAEPBOPReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAEPBOPReqV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be1e100">
                          <SHORT-NAME>APAEnRunReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAEnRunReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnRunReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124abd00">
                          <SHORT-NAME>APAF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAF_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb98900">
                          <SHORT-NAME>APAOneKeyParkSwReq_APAOneKeyParkSwReq_APAOneKeyParkSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAOneKeyParkSwReq_APAOneKeyParkSwReq_APAOneKeyParkSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAOneKeyParkSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb94d00">
                          <SHORT-NAME>APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_APAParkInOffsetTypeReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAParkInOffsetTypeReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf2c00">
                          <SHORT-NAME>APAParkInOffsetType_APAParkInOffsetType_APAParkInOffsetType</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAParkInOffsetType_APAParkInOffsetType_APAParkInOffsetType_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAParkInOffsetType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbeff00">
                          <SHORT-NAME>APARemShifGear_APARemShifGear_APARemShifGear</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APARemShifGear_APARemShifGear_APARemShifGear_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPARemShifGear</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f47300">
                          <SHORT-NAME>APARevrDrgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APARevrDrgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPARevrDrgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed4800">
                          <SHORT-NAME>APASCSAcclReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASCSAcclReqSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSAcclReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdcf400">
                          <SHORT-NAME>APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124aca00">
                          <SHORT-NAME>APASCUReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASCUReqSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124ad700">
                          <SHORT-NAME>APASCUReqStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASCUReqStsV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb8e400">
                          <SHORT-NAME>APASWReq_APASWReq_APASWReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASWReq_APASWReq_APASWReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASWReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc04900">
                          <SHORT-NAME>APASW_APASW_APASW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASW_APASW_APASW_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124ae400">
                          <SHORT-NAME>APAShifterPosReqd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAShifterPosReqd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124af100">
                          <SHORT-NAME>APAShifterPosReqdV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAShifterPosReqdV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqdV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f3a1b413231d8d00">
                          <SHORT-NAME>APASpdMdSwSts_APASpdMdSwSts_APASpdMdSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASpdMdSwSts_APASpdMdSwSts_APASpdMdSwSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASpdMdSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bccfc00">
                          <SHORT-NAME>APASts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APASts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f4a700">
                          <SHORT-NAME>APAToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAToqReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f57700">
                          <SHORT-NAME>APATotWhlToqReqVal</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APATotWhlToqReqVal_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATotWhlToqReqVal</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a031a0313b664124afe00">
                          <SHORT-NAME>APATrgtEPSStrgWhlAng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APATrgtEPSStrgWhlAng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATrgtEPSStrgWhlAng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f5e2186131f4db00">
                          <SHORT-NAME>APAVCUReqSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAVCUReqSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVCUReqSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd0400">
                          <SHORT-NAME>APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatAzmth</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd1400">
                          <SHORT-NAME>APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosX</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd2400">
                          <SHORT-NAME>APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosY</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb91100">
                          <SHORT-NAME>AVMDspReq_AVMDspReq_AVMDspReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AVMDspReq_AVMDspReq_AVMDspReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVMDspReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb9f200">
                          <SHORT-NAME>AVMSt_AVMSt_AVMSt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AVMSt_AVMSt_AVMSt_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVMSt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c047800">
                          <SHORT-NAME>AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_AVPMapRutMgIDtReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVPMapRutMgIDtReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbbf4000">
                          <SHORT-NAME>AltSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AltSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAltSigma</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbc23800">
                          <SHORT-NAME>AltitudeRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AltitudeRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAltitudeRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd3400">
                          <SHORT-NAME>AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngLLaneSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc7900">
                          <SHORT-NAME>AutoLaneChngMsgReq_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngMsgReq_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd4400">
                          <SHORT-NAME>AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngRLaneSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb86c00">
                          <SHORT-NAME>AutoLaneChngSetReq_AutoLaneChngSetReq_AutoLaneChngSetReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngSetReq_AutoLaneChngSetReq_AutoLaneChngSetReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSetReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc8800">
                          <SHORT-NAME>AutoLaneChngSetResp_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngSetResp_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSetResp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc9700">
                          <SHORT-NAME>AutoLaneChngSwDspCmd_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngSwDspCmd_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSwDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba3d00">
                          <SHORT-NAME>AutoLaneChngSwReq_AutoLaneChngSwReq_AutoLaneChngSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngSwReq_AutoLaneChngSwReq_AutoLaneChngSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba6a00">
                          <SHORT-NAME>AutoLaneChngVcCmd_AutoLaneChngVcCmd_AutoLaneChngVcCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoLaneChngVcCmd_AutoLaneChngVcCmd_AutoLaneChngVcCmd_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngVcCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9b1f00">
                          <SHORT-NAME>AutoMainBeamLghtOn_AutoMainBeamLghtOn_AutoMainBeamLghtOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoMainBeamLghtOn_AutoMainBeamLghtOn_AutoMainBeamLghtOn_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoMainBeamLghtOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcd3800">
                          <SHORT-NAME>AutoMainBeamLghtReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutoMainBeamLghtReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoMainBeamLghtReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be5b800">
                          <SHORT-NAME>AutocParkngSwReq_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutocParkngSwReq_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocParkngSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bec8500">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysEmgcBrkReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bec9400">
                          <SHORT-NAME>AutodDrvngSysEmgcBrkReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysEmgcBrkReqV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed5700">
                          <SHORT-NAME>AutodDrvngSysFlrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysFlrSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed6600">
                          <SHORT-NAME>AutodDrvngSysFlrStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysFlrStsV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed7500">
                          <SHORT-NAME>AutodDrvngSysMdReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysMdReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed8400">
                          <SHORT-NAME>AutodDrvngSysMdReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysMdReqV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bed9300">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysSCSDrvOffReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beda200">
                          <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysSCSDrvOffReqV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bedb100">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysSCSSdslReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bedc000">
                          <SHORT-NAME>AutodDrvngSysSCSSdslReqV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysSCSSdslReqV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReqV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bcd0b00">
                          <SHORT-NAME>AutodDrvngSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdc5b00">
                          <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf0cc00">
                          <SHORT-NAME>BPMMstrAvlbly</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BPMMstrAvlbly_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBPMMstrAvlbly</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb92000">
                          <SHORT-NAME>BSDSelReq_BSDSelReq_BSDSelReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BSDSelReq_BSDSelReq_BSDSelReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBSDSelReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd46d00">
                          <SHORT-NAME>BSDSelSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BSDSelSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBSDSelSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba80400">
                          <SHORT-NAME>BaseLineLen_BaseLineLen_BaseLineLen</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BaseLineLen_BaseLineLen_BaseLineLen_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBaseLineLen</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba71400">
                          <SHORT-NAME>BntOpenSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BntOpenSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBntOpenSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba66f00">
                          <SHORT-NAME>BrkLghtCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf93300">
                          <SHORT-NAME>BrkLghtFltSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtFltSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bedde00">
                          <SHORT-NAME>BrkLghtFltSts_HW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtFltSts_HW_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSts_HW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf94200">
                          <SHORT-NAME>BrkLghtSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3beded00">
                          <SHORT-NAME>BrkLghtSts_HW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtSts_HW_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSts_HW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be42000">
                          <SHORT-NAME>BrkLghtSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/BrkLghtSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bab2e00">
                          <SHORT-NAME>CANprotocolinternalversion_CANprotocolinternalversion_CANprotocolinternalversion</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CANprotocolinternalversion_CANprotocolinternalversion_CANprotocolinternalversion_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICANprotocolinternalversion</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdf6900">
                          <SHORT-NAME>CCDisAdjtVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCDisAdjtVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisAdjtVcCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc38500">
                          <SHORT-NAME>CCDisDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCDisDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisDecAndIncVcCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc39500">
                          <SHORT-NAME>CCSpdDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSpdDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdDecAndIncVcCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd55d00">
                          <SHORT-NAME>CCSpdVcCmdCnfm_CCSpdVcCmdCnfm_CCSpdVcCmdCnfm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSpdVcCmdCnfm_CCSpdVcCmdCnfm_CCSpdVcCmdCnfm_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmdCnfm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc3a500">
                          <SHORT-NAME>CCSpdVcCmdSwReq_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSpdVcCmdSwReq_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmdSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdf7900">
                          <SHORT-NAME>CCSpdVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSpdVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9d7100">
                          <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSpdlVcCmdSwReqDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdlVcCmdSwReqDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc3b500">
                          <SHORT-NAME>CCSwStsCCASwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsCCASwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCCASwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d1cf00">
                          <SHORT-NAME>CCSwStsCanclSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsCanclSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCanclSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d20300">
                          <SHORT-NAME>CCSwStsDistDecSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsDistDecSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistDecSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d23700">
                          <SHORT-NAME>CCSwStsDistIncSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsDistIncSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistIncSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d26b00">
                          <SHORT-NAME>CCSwStsOnSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsOnSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsOnSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d29f00">
                          <SHORT-NAME>CCSwStsRsmSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsRsmSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsRsmSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc3c500">
                          <SHORT-NAME>CCSwStsSetSwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsSetSwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSetSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d2d300">
                          <SHORT-NAME>CCSwStsSpdDecSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsSpdDecSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdDecSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d30700">
                          <SHORT-NAME>CCSwStsSpdIncSwA</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsSpdIncSwA_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdIncSwA</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d33b00">
                          <SHORT-NAME>CCSwStsSwDataIntgty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/CCSwStsSwDataIntgty_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSwDataIntgty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bedfc00">
                          <SHORT-NAME>ChrgrFlapLtchCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ChrgrFlapLtchCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChrgrFlapLtchCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3befdc00">
                          <SHORT-NAME>ClstrDspdAirbagWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ClstrDspdAirbagWrnng_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdAirbagWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd61a00">
                          <SHORT-NAME>ClstrDspdVehSpd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ClstrDspdVehSpd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdVehSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd6d800">
                          <SHORT-NAME>ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdVehSpd_mph</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bafed00">
                          <SHORT-NAME>ComKeyEnbReq_ComKeyEnbReq_ComKeyEnbReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ComKeyEnbReq_ComKeyEnbReq_ComKeyEnbReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IComKeyEnbReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd53f00">
                          <SHORT-NAME>D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_D2DPriETClanSwReqResps</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DPriETClanSwReqResps</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd75000">
                          <SHORT-NAME>D2DPriETClanSwReq_D2DPriETClanSwReq_D2DPriETClanSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/D2DPriETClanSwReq_D2DPriETClanSwReq_D2DPriETClanSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DPriETClanSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd5ab00">
                          <SHORT-NAME>D2DSwReqResps_D2DSwReqResps_D2DSwReqResps</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/D2DSwReqResps_D2DSwReqResps_D2DSwReqResps_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DSwReqResps</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd70500">
                          <SHORT-NAME>D2DSwReq_D2DSwReq_D2DSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/D2DSwReq_D2DSwReq_D2DSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd5d800">
                          <SHORT-NAME>D2DSysSts_D2DSysSts_D2DSysSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/D2DSysSts_D2DSysSts_D2DSysSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdca600">
                          <SHORT-NAME>DILampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DILampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDILampsCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c062700">
                          <SHORT-NAME>DMSCameraFps_IMM_DMSCameraFps_IMM_DMSCameraFps_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DMSCameraFps_IMM_DMSCameraFps_IMM_DMSCameraFps_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSCameraFps_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a2000">
                          <SHORT-NAME>DMSSts_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DMSSts_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbac400">
                          <SHORT-NAME>DOWSelReq_DOWSelReq_DOWSelReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DOWSelReq_DOWSelReq_DOWSelReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDOWSelReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd47c00">
                          <SHORT-NAME>DOWSelSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DOWSelSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDOWSelSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9cd400">
                          <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DTCInfomationIPD_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDTCInfomationIPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbea500">
                          <SHORT-NAME>DetourMsgReq_DetourMsgReq_DetourMsgReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DetourMsgReq_DetourMsgReq_DetourMsgReq_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDetourMsgReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03c000">
                          <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DfstOnDspCmd_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDfstOnDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bacb400">
                          <SHORT-NAME>DiffAgeInfo_DiffAgeInfo_DiffAgeInfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DiffAgeInfo_DiffAgeInfo_DiffAgeInfo_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDiffAgeInfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba9e400">
                          <SHORT-NAME>DiffDataLinkBroken_DiffDataLinkBroken_DiffDataLinkBroken</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DiffDataLinkBroken_DiffDataLinkBroken_DiffDataLinkBroken_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDiffDataLinkBroken</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c3000">
                          <SHORT-NAME>DigKeyAuthReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DigKeyAuthReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyAuthReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c4000">
                          <SHORT-NAME>DigKeyPEValidReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DigKeyPEValidReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyPEValidReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c003300">
                          <SHORT-NAME>DippedBeamActStatus_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DippedBeamActStatus_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDippedBeamActStatus</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf8f700">
                          <SHORT-NAME>DircnIndLampSwStsMntry_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnIndLampSwStsMntry_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLampSwStsMntry</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba6f600">
                          <SHORT-NAME>DircnIndLghtMdSts_DircnIndLghtMdSts_DircnIndLghtMdSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnIndLghtMdSts_DircnIndLghtMdSts_DircnIndLghtMdSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLghtMdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b993f00">
                          <SHORT-NAME>DircnIndLghtSwSts_DircnIndLghtSwSts_DircnIndLghtSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnIndLghtSwSts_DircnIndLghtSwSts_DircnIndLghtSwSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLghtSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf95100">
                          <SHORT-NAME>DircnLghtFltsts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnLghtFltsts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtFltsts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf96000">
                          <SHORT-NAME>DircnLghtMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnLghtMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtMdSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be4a800">
                          <SHORT-NAME>DircnLghtOnReq_LHZCU</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnLghtOnReq_LHZCU_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtOnReq_LHZCU</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf96f00">
                          <SHORT-NAME>DircnLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf97e00">
                          <SHORT-NAME>DircnLghtSwReq_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DircnLghtSwReq_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf7bc00">
                          <SHORT-NAME>DirnLghtSftyMonErr_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DirnLghtSftyMonErr_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDirnLghtSftyMonErr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c081700">
                          <SHORT-NAME>DistSinceTrgtCamr_DistSinceTrgtCamr_DistSinceTrgtCamr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DistSinceTrgtCamr_DistSinceTrgtCamr_DistSinceTrgtCamr_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistSinceTrgtCamr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb2420b00">
                          <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DistToTrfcJamNav_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistToTrfcJamNav</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bae1c00">
                          <SHORT-NAME>DownVelocityRTK_DownVelocityRTK_DownVelocityRTK</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DownVelocityRTK_DownVelocityRTK_DownVelocityRTK_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDownVelocityRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a3000">
                          <SHORT-NAME>DrvrAbnormBehvor_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrAbnormBehvor_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormBehvor_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ae000">
                          <SHORT-NAME>DrvrAbnormConf_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrAbnormConf_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormConf_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba72300">
                          <SHORT-NAME>DrvrDetSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDetSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDetSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba73200">
                          <SHORT-NAME>DrvrDoorOpenSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDoorOpenSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDoorOpenSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ad000">
                          <SHORT-NAME>DrvrDstcnConf_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDstcnConf_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnConf_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a0000">
                          <SHORT-NAME>DrvrDstcnStsINST_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDstcnStsINST_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnStsINST_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a4000">
                          <SHORT-NAME>DrvrDstcnSts_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDstcnSts_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnSts_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba7900">
                          <SHORT-NAME>DrvrDstrctnSts_DrvrDstrctnSts_DrvrDstrctnSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrDstrctnSts_DrvrDstrctnSts_DrvrDstrctnSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstrctnSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ac000">
                          <SHORT-NAME>DrvrFtgConf_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrFtgConf_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgConf_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a1000">
                          <SHORT-NAME>DrvrFtgLvlINST_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrFtgLvlINST_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvlINST_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb9d400">
                          <SHORT-NAME>DrvrFtgLvl_DrvrFtgLvl_DrvrFtgLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrFtgLvl_DrvrFtgLvl_DrvrFtgLvl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a5000">
                          <SHORT-NAME>DrvrFtgLvl_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrFtgLvl_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvl_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a6000">
                          <SHORT-NAME>DrvrGazeRgn_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrGazeRgn_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrGazeRgn_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a7000">
                          <SHORT-NAME>DrvrPrst_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrPrst_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrPrst_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be36500">
                          <SHORT-NAME>DrvrReqGearShftPos</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrReqGearShftPos_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be37600">
                          <SHORT-NAME>DrvrReqGearShftPosInvs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrReqGearShftPosInvs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPosInvs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0c5000">
                          <SHORT-NAME>DrvrReqParkBtn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DrvrReqParkBtn_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqParkBtn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd65000">
                          <SHORT-NAME>DspMeasmtSys_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/DspMeasmtSys_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDspMeasmtSys</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd35d00">
                          <SHORT-NAME>ELKDspCmd_ELKDspCmd_ELKDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ELKDspCmd_ELKDspCmd_ELKDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a0200">
                          <SHORT-NAME>ELKSwReq_ELKSwReq_ELKSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ELKSwReq_ELKSwReq_ELKSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd36d00">
                          <SHORT-NAME>ELKSysFltSts_ELKSysFltSts_ELKSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ELKSysFltSts_ELKSysFltSts_ELKSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c07e700">
                          <SHORT-NAME>ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSysSts_IPD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb11900">
                          <SHORT-NAME>ELKWarning</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ELKWarning_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKWarning</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c044a00">
                          <SHORT-NAME>EORWarningEvtSts_EORWarningEvtSts_EORWarningEvtSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EORWarningEvtSts_EORWarningEvtSts_EORWarningEvtSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEORWarningEvtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc3f300">
                          <SHORT-NAME>EPSAvlbly</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EPSAvlbly_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAvlbly</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3befeb00">
                          <SHORT-NAME>EPTNotReadyReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EPTNotReadyReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTNotReadyReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd33f00">
                          <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESCLPwrSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESCLPwrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc0c100">
                          <SHORT-NAME>ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSAdoWrnngDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbb0f00">
                          <SHORT-NAME>ESSAdoWrnngReq_ESSAdoWrnngReq_ESSAdoWrnngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSAdoWrnngReq_ESSAdoWrnngReq_ESSAdoWrnngReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSAdoWrnngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd5400">
                          <SHORT-NAME>ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDirInd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd6400">
                          <SHORT-NAME>ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDrvrTkovReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc19300">
                          <SHORT-NAME>ESSDspCmd_ESSDspCmd_ESSDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSDspCmd_ESSDspCmd_ESSDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd7400">
                          <SHORT-NAME>ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdd8400">
                          <SHORT-NAME>ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb99800">
                          <SHORT-NAME>ESSswReq_ESSswReq_ESSswReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ESSswReq_ESSswReq_ESSswReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSswReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baa6b00">
                          <SHORT-NAME>EastVelocityRTK_EastVelocityRTK_EastVelocityRTK</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EastVelocityRTK_EastVelocityRTK_EastVelocityRTK_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEastVelocityRTK</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bb18200">
                          <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/ElecPwrDistbnScene_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IElecPwrDistbnScene</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be38700">
                          <SHORT-NAME>EleccTrRngReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EleccTrRngReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEleccTrRngReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd37d00">
                          <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/En12VoltStrMotCmddOn_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEn12VoltStrMotCmddOn</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff4c00">
                          <SHORT-NAME>EvtPotclSigIPD1_EvtPotclSigIPD1_EvtPotclSigIPD1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD1_EvtPotclSigIPD1_EvtPotclSigIPD1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff8800">
                          <SHORT-NAME>EvtPotclSigIPD2_EvtPotclSigIPD2_EvtPotclSigIPD2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD2_EvtPotclSigIPD2_EvtPotclSigIPD2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff7900">
                          <SHORT-NAME>EvtPotclSigIPD3_EvtPotclSigIPD3_EvtPotclSigIPD3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD3_EvtPotclSigIPD3_EvtPotclSigIPD3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff2e00">
                          <SHORT-NAME>EvtPotclSigIPD4_EvtPotclSigIPD4_EvtPotclSigIPD4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD4_EvtPotclSigIPD4_EvtPotclSigIPD4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff1f00">
                          <SHORT-NAME>EvtPotclSigIPD5_EvtPotclSigIPD5_EvtPotclSigIPD5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD5_EvtPotclSigIPD5_EvtPotclSigIPD5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff5b00">
                          <SHORT-NAME>EvtPotclSigIPD6_EvtPotclSigIPD6_EvtPotclSigIPD6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD6_EvtPotclSigIPD6_EvtPotclSigIPD6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bff3d00">
                          <SHORT-NAME>EvtPotclSigIPD7_EvtPotclSigIPD7_EvtPotclSigIPD7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD7_EvtPotclSigIPD7_EvtPotclSigIPD7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfef200">
                          <SHORT-NAME>EvtPotclSigIPD8_EvtPotclSigIPD8_EvtPotclSigIPD8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EvtPotclSigIPD8_EvtPotclSigIPD8_EvtPotclSigIPD8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEvtPotclSigIPD8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0b4000">
                          <SHORT-NAME>EyeGazepitch_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeGazepitch_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazepitch_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0b5000">
                          <SHORT-NAME>EyeGazeyaw_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeGazeyaw_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazeyaw_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfb9b00">
                          <SHORT-NAME>EyeOffRoadDetnSta</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeOffRoadDetnSta_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnSta</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfbac00">
                          <SHORT-NAME>EyeOffRoadDetnStaV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeOffRoadDetnStaV_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnStaV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0a8000">
                          <SHORT-NAME>EyeOnRoad_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeOnRoad_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOnRoad_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0b6000">
                          <SHORT-NAME>EyeOpenDegree_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeOpenDegree_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenDegree_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0af000">
                          <SHORT-NAME>EyeOpenStatus_IMM</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/EyeOpenStatus_IMM_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenStatus_IMM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdbc500">
                          <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTBSysFltSts_ADAS_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTBSysFltSts_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd60600">
                          <SHORT-NAME>FCTBSysFltSts_FCTBSysFltSts_FCTBSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTBSysFltSts_FCTBSysFltSts_FCTBSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTBSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdbd400">
                          <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTSwSts_ADAS_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSwSts_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc24700">
                          <SHORT-NAME>FCTSwSts_FCTSwSts_FCTSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTSwSts_FCTSwSts_FCTSwSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdbe300">
                          <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTSysFltSts_ADAS_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSysFltSts_ADAS</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc0a300">
                          <SHORT-NAME>FCTSysFltSts_FCTSysFltSts_FCTSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTSysFltSts_FCTSysFltSts_FCTSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bba8800">
                          <SHORT-NAME>FCTSysSelReq_FCTSysSelReq_FCTSysSelReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCTSysSelReq_FCTSysSelReq_FCTSysSelReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCTSysSelReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba20200">
                          <SHORT-NAME>FCWDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba25000">
                          <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWSnstvtLvl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSnstvtLvl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b99a800">
                          <SHORT-NAME>FCWSnstvtLvlReq_FCWSnstvtLvlReq_FCWSnstvtLvlReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWSnstvtLvlReq_FCWSnstvtLvlReq_FCWSnstvtLvlReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSnstvtLvlReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9a3e00">
                          <SHORT-NAME>FCWSwReq_FCWSwReq_FCWSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWSwReq_FCWSwReq_FCWSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb9ccc200">
                          <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWSysFltSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb9cd7e00">
                          <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FCWrnngSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWrnngSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba65100">
                          <SHORT-NAME>FDRPwrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDRPwrSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRPwrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c0000">
                          <SHORT-NAME>FDRSts_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDRSts_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c0f00">
                          <SHORT-NAME>FDR_100ms_Group01_CRC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_CRC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9bf100">
                          <SHORT-NAME>FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFDR_100ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c1e00">
                          <SHORT-NAME>FDR_100ms_Group01_RC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_RC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c2d00">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved1_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved1_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c3c00">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved2_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved2_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c4b00">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved3_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved3_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c5a00">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved4_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved4_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c6900">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved5_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved5_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c7800">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved6_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved6_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9c8700">
                          <SHORT-NAME>FDR_100ms_Group01_Reserved7_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FDR_100ms_Group01_Reserved7_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba67e00">
                          <SHORT-NAME>FLDircnLghtCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLDircnLghtCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be5c700">
                          <SHORT-NAME>FLDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtFltsts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9b2e00">
                          <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLDircnLghtSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc27400">
                          <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLDoorHndlPESwtActv_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDoorHndlPESwtActv</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd64200">
                          <SHORT-NAME>FLDoorOpenSts_FLDoorOpenSts_FLDoorOpenSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLDoorOpenSts_FLDoorOpenSts_FLDoorOpenSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDoorOpenSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc1de00">
                          <SHORT-NAME>FLObsRng_FLObsRng_FLObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLObsRng_FLObsRng_FLObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc25600">
                          <SHORT-NAME>FLSObsRng_FLSObsRng_FLSObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSObsRng_FLSObsRng_FLSObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbfb300">
                          <SHORT-NAME>FLSUSSSts_FLSUSSSts_FLSUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSUSSSts_FLSUSSSts_FLSUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbd68600">
                          <SHORT-NAME>FLSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHeatCtrlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bde7a00">
                          <SHORT-NAME>FLSeatHorzPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSeatHorzPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHorzPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f498f2acb36c7400">
                          <SHORT-NAME>FLSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVentCtrlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bf7cb00">
                          <SHORT-NAME>FLSeatVertPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSeatVertPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVertPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc03a00">
                          <SHORT-NAME>FLSideObsRng_FLSideObsRng_FLSideObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLSideObsRng_FLSideObsRng_FLSideObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSideObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb1100">
                          <SHORT-NAME>FLTirePrs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLTirePrs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTirePrs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb2000">
                          <SHORT-NAME>FLTirePrsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLTirePrsV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTirePrsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f498f2acb4094b00">
                          <SHORT-NAME>FLTireSts_FLTireSts_FLTireSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLTireSts_FLTireSts_FLTireSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bda2100">
                          <SHORT-NAME>FLTireTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLTireTem_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb7a00">
                          <SHORT-NAME>FLTireTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLTireTemV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLTireTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd1f00">
                          <SHORT-NAME>FLUSSSts_FLUSSSts_FLUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLUSSSts_FLUSSSts_FLUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd2f400">
                          <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FLiDARPwrSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLiDARPwrSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbbb400">
                          <SHORT-NAME>FMLUSSSts_FMLUSSSts_FMLUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FMLUSSSts_FMLUSSSts_FMLUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMLUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbbff00">
                          <SHORT-NAME>FMRUSSSts_FMRUSSSts_FMRUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FMRUSSSts_FMRUSSSts_FMRUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMRUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd31200">
                          <SHORT-NAME>FOTAStatus</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FOTAStatus_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTAStatus</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd32100">
                          <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FOTAStatusValid_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTAStatusValid</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd33000">
                          <SHORT-NAME>FOTATarget</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FOTATarget_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTATarget</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd30300">
                          <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FOTATargetValid_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTATargetValid</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba68d00">
                          <SHORT-NAME>FRDircnLghtCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRDircnLghtCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be5d600">
                          <SHORT-NAME>FRDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtFltsts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b9b3d00">
                          <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRDircnLghtSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc26500">
                          <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRDoorHndlPESwtActv_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDoorHndlPESwtActv</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd66f00">
                          <SHORT-NAME>FRDoorOpenSts_FRDoorOpenSts_FRDoorOpenSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRDoorOpenSts_FRDoorOpenSts_FRDoorOpenSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDoorOpenSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc02b00">
                          <SHORT-NAME>FRObsRng_FRObsRng_FRObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRObsRng_FRObsRng_FRObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbbc300">
                          <SHORT-NAME>FRSObsRng_FRSObsRng_FRSObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSObsRng_FRSObsRng_FRSObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbf0e00">
                          <SHORT-NAME>FRSUSSSts_FRSUSSSts_FRSUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSUSSSts_FRSUSSSts_FRSUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f498f2acb36c3d00">
                          <SHORT-NAME>FRSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatHeatCtrlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c087f00">
                          <SHORT-NAME>FRSeatHorzPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSeatHorzPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatHorzPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f498f2acb36caa00">
                          <SHORT-NAME>FRSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatVentCtrlSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c088f00">
                          <SHORT-NAME>FRSeatVertPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSeatVertPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatVertPos</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbda600">
                          <SHORT-NAME>FRSideObsRng_FRSideObsRng_FRSideObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRSideObsRng_FRSideObsRng_FRSideObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSideObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb8900">
                          <SHORT-NAME>FRTirePrs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRTirePrs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTirePrs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bda6c00">
                          <SHORT-NAME>FRTirePrsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRTirePrsV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTirePrsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f498f2acb4078100">
                          <SHORT-NAME>FRTireSts_FRTireSts_FRTireSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRTireSts_FRTireSts_FRTireSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdab700">
                          <SHORT-NAME>FRTireTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRTireTem_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb3e00">
                          <SHORT-NAME>FRTireTemV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRTireTemV_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRTireTemV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbca600">
                          <SHORT-NAME>FRUSSSts_FRUSSSts_FRUSSSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FRUSSSts_FRUSSSts_FRUSSSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRUSSSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa1400">
                          <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IFVCM_20ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa2500">
                          <SHORT-NAME>FVCM_20ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_CRC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bfa3600">
                          <SHORT-NAME>FVCM_20ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_RC_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e6200">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved1_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e6d00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved2_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e7800">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved3_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e8300">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved4_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e8e00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved5_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0e9900">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved6_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0ea400">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved7_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c0eaf00">
                          <SHORT-NAME>FVCM_20ms_Group02_Reserved8</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FVCM_20ms_Group02_Reserved8_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved8</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb59a00">
                          <SHORT-NAME>FixType_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FixType_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFixType</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3be5a900">
                          <SHORT-NAME>FrSsdManuCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrSsdManuCtrl_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrSsdManuCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c040b00">
                          <SHORT-NAME>FrtCamrHeatCtrl_FrtCamrHeatCtrl_FrtCamrHeatCtrl</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtCamrHeatCtrl_FrtCamrHeatCtrl_FrtCamrHeatCtrl_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCamrHeatCtrl</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c045a00">
                          <SHORT-NAME>FrtCamrHeatSts_FrtCamrHeatSts_FrtCamrHeatSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtCamrHeatSts_FrtCamrHeatSts_FrtCamrHeatSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCamrHeatSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbd7900">
                          <SHORT-NAME>FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfrDspCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbaa600">
                          <SHORT-NAME>FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfrSwReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bde1100">
                          <SHORT-NAME>FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc6a00">
                          <SHORT-NAME>FrtMidLObsRng_FrtMidLObsRng_FrtMidLObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtMidLObsRng_FrtMidLObsRng_FrtMidLObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtMidLObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc06700">
                          <SHORT-NAME>FrtMidRObsRng_FrtMidRObsRng_FrtMidRObsRng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtMidRObsRng_FrtMidRObsRng_FrtMidRObsRng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtMidRObsRng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bbc4c00">
                          <SHORT-NAME>FrtObsDist_FrtObsDist_FrtObsDist</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtObsDist_FrtObsDist_FrtObsDist_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtObsDist</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bc15700">
                          <SHORT-NAME>FrtPDCAudWrnng_FrtPDCAudWrnng_FrtPDCAudWrnng</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtPDCAudWrnng_FrtPDCAudWrnng_FrtPDCAudWrnng_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPDCAudWrnng</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef2800">
                          <SHORT-NAME>FrtPsngAirbagSwStsReqV_Sfty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtPsngAirbagSwStsReqV_Sfty_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReqV_Sfty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bef3700">
                          <SHORT-NAME>FrtPsngAirbagSwStsReq_Sfty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtPsngAirbagSwStsReq_Sfty_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReq_Sfty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bd67e00">
                          <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtPsngDoorOpenSts_LHZCU_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngDoorOpenSts_LHZCU</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3bdb2f00">
                          <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtTireStdPrs_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtTireStdPrs</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03ed00">
                          <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtWindShldSfcTem_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSfcTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03cf00">
                          <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtWindShldSurndHmdty_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSurndHmdty</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c03fc00">
                          <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtWindShldSurndTem_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWindShldSurndTem</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b995d00">
                          <SHORT-NAME>FrtWiperSpd_FrtWiperSpd_FrtWiperSpd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtWiperSpd_FrtWiperSpd_FrtWiperSpd_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWiperSpd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b994e00">
                          <SHORT-NAME>FrtWiperSwSts_FrtWiperSwSts_FrtWiperSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/FrtWiperSwSts_FrtWiperSwSts_FrtWiperSwSts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtWiperSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3baa2f00">
                          <SHORT-NAME>GNSSAntennasBroken_GNSSAntennasBroken_GNSSAntennasBroken</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSAntennasBroken_GNSSAntennasBroken_GNSSAntennasBroken_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSAntennasBroken</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3ba8d600">
                          <SHORT-NAME>GNSSAntennasInfo_GNSSAntennasInfo_GNSSAntennasInfo</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSAntennasInfo_GNSSAntennasInfo_GNSSAntennasInfo_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSAntennasInfo</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb99600">
                          <SHORT-NAME>GNSSF9HCounter_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSF9HCounter_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSF9HCounter</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb5cf00">
                          <SHORT-NAME>GNSSSeq_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSSeq_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSSeq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb60400">
                          <SHORT-NAME>GNSSUTCTimeH_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSUTCTimeH_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSUTCTimeH</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdbbb9cb00">
                          <SHORT-NAME>GNSSUTCTime_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/GNSSUTCTime_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSUTCTime</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xNa505a3f19f34f4acdb8d64700">
                          <SHORT-NAME>HMISafFltsts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HMISafFltsts_IPD_BKPCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHMISafFltsts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3c041a00">
                          <SHORT-NAME>HORWarningEvtSts_HORWarningEvtSts_HORWarningEvtSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_BKPCANFD/HORWarningEvtSts_HORWarningEvtSts_HORWarningEvtSts_IPD_BKPCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
