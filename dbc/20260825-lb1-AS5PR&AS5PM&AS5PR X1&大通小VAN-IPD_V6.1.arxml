                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDFC_Current_DisplyBuffer_0</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8cb100">
                          <SHORT-NAME>DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDFC_Current_DisplyBuffer_1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d2900">
                          <SHORT-NAME>DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDFC_Current_DisplyBuffer_2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8eaf00">
                          <SHORT-NAME>DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvTqReqWhlFilt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8cc000">
                          <SHORT-NAME>DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvTqReqWhlRawCap_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c0c00">
                          <SHORT-NAME>DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvTqReqWhlRaw_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9cfa00">
                          <SHORT-NAME>DrvrSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DrvrSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9d0d00">
                          <SHORT-NAME>DrvrSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DrvrSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ba300">
                          <SHORT-NAME>DsblICE_flg_DsblICE_flg_DsblICE_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DsblICE_flg_DsblICE_flg_DsblICE_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDsblICE_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c1b00">
                          <SHORT-NAME>DsblISG_flg_DsblISG_flg_DsblISG_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/DsblISG_flg_DsblISG_flg_DsblISG_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDsblISG_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8f1800">
                          <SHORT-NAME>ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCBrkRgnPwrLmt_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8edc00">
                          <SHORT-NAME>ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCChrgPwrLmtPeak_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e6400">
                          <SHORT-NAME>ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCChrgPwrLmtWhl_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b3900">
                          <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCDsChrgPwrLmtPeak_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bd000">
                          <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCDsChrgPwrLmtWhl_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c8400">
                          <SHORT-NAME>ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCEmgcyPwrDwn_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b2a00">
                          <SHORT-NAME>ERCFCOReq_flg_ERCFCOReq_flg_ERCFCOReq_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCFCOReq_flg_ERCFCOReq_flg_ERCFCOReq_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCFCOReq_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e9100">
                          <SHORT-NAME>ERCHVAllwd_flg_ERCHVAllwd_flg_ERCHVAllwd_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCHVAllwd_flg_ERCHVAllwd_flg_ERCHVAllwd_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCHVAllwd_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c4800">
                          <SHORT-NAME>ERCHVHldReq_flg_ERCHVHldReq_flg_ERCHVHldReq_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCHVHldReq_flg_ERCHVHldReq_flg_ERCHVHldReq_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCHVHldReq_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e8200">
                          <SHORT-NAME>ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCMaxChrgPwrLmt_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d4700">
                          <SHORT-NAME>ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IERCMaxDschgPwrLmt_kW</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b1b00">
                          <SHORT-NAME>EVMd_flg_EVMd_flg_EVMd_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EVMd_flg_EVMd_flg_EVMd_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEVMd_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8cde00">
                          <SHORT-NAME>EngBrkTqMax_Nm_EngBrkTqMax_Nm_EngBrkTqMax_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngBrkTqMax_Nm_EngBrkTqMax_Nm_EngBrkTqMax_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngBrkTqMax_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ca200">
                          <SHORT-NAME>EngFastTqReq_Nm_EngFastTqReq_Nm_EngFastTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngFastTqReq_Nm_EngFastTqReq_Nm_EngFastTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngFastTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8dce00">
                          <SHORT-NAME>EngFastTqTypReq_enum_EngFastTqTypReq_enum_EngFastTqTypReq_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngFastTqTypReq_enum_EngFastTqTypReq_enum_EngFastTqTypReq_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngFastTqTypReq_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ea000">
                          <SHORT-NAME>EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngFlexplateTqFstTgt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ecd00">
                          <SHORT-NAME>EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngFlexplateTqSlowTgt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8f0900">
                          <SHORT-NAME>EngPhsAng_deg_EngPhsAng_deg_EngPhsAng_deg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngPhsAng_deg_EngPhsAng_deg_EngPhsAng_deg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngPhsAng_deg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8efa00">
                          <SHORT-NAME>EngSlowTqReq_Nm_EngSlowTqReq_Nm_EngSlowTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngSlowTqReq_Nm_EngSlowTqReq_Nm_EngSlowTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngSlowTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e4600">
                          <SHORT-NAME>EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngSpdSafe4EngStrt_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e1900">
                          <SHORT-NAME>EngStallCnt_cnt_EngStallCnt_cnt_EngStallCnt_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStallCnt_cnt_EngStallCnt_cnt_EngStallCnt_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStallCnt_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e5500">
                          <SHORT-NAME>EngStall_cnt_EngStall_cnt_EngStall_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStall_cnt_EngStall_cnt_EngStall_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStall_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8da100">
                          <SHORT-NAME>EngStopReqCfmd_flg_EngStopReqCfmd_flg_EngStopReqCfmd_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStopReqCfmd_flg_EngStopReqCfmd_flg_EngStopReqCfmd_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStopReqCfmd_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b4800">
                          <SHORT-NAME>EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtDampSlipFailCnt_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bdf00">
                          <SHORT-NAME>EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_EngStrtFailCnt_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtFailCnt_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8dbf00">
                          <SHORT-NAME>EngStrtFail_cnt_EngStrtFail_cnt_EngStrtFail_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtFail_cnt_EngStrtFail_cnt_EngStrtFail_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtFail_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d3800">
                          <SHORT-NAME>EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtNoCapFailCnt_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d7400">
                          <SHORT-NAME>EngStrtReq_flg_EngStrtReq_flg_EngStrtReq_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtReq_flg_EngStrtReq_flg_EngStrtReq_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtReq_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8eeb00">
                          <SHORT-NAME>EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEngStrtStuckFailCnt_cnt</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f34f4acdb9ccfc00">
                          <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FCWSysFltSts_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSysFltSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f34f4acdb9cd4400">
                          <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FCWrnngSts_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWrnngSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f498f2acb398a900">
                          <SHORT-NAME>FMOccupntSts_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FMOccupntSts_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMOccupntSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b1f00">
                          <SHORT-NAME>FasnDrvrSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnDrvrSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cd65a00">
                          <SHORT-NAME>FasnDrvrSbltIndCmdEvtTyp_SDM_20ms_Group01_SDM_20ms_Group01_SDM_20ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnDrvrSbltIndCmdEvtTyp_SDM_20ms_Group01_SDM_20ms_Group01_SDM_20ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmdEvtTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b3200">
                          <SHORT-NAME>FasnFrtPsngSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnFrtPsngSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtPsngSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f498f2acb398f100">
                          <SHORT-NAME>FasnFrtRowMidSbltAtcV_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnFrtRowMidSbltAtcV_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f498f2acb398cd00">
                          <SHORT-NAME>FasnFrtRowMidSbltAtc_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnFrtRowMidSbltAtc_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxNa505a3f19f498f2acb3991500">
                          <SHORT-NAME>FasnFrtRowMidSbltIndCmd_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnFrtRowMidSbltIndCmd_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b4500">
                          <SHORT-NAME>FasnSbltAudRmndr</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSbltAudRmndr_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSbltAudRmndr</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b5800">
                          <SHORT-NAME>FasnSecRowLSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowLSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b6b00">
                          <SHORT-NAME>FasnSecRowLSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowLSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b7e00">
                          <SHORT-NAME>FasnSecRowLSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowLSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9b9100">
                          <SHORT-NAME>FasnSecRowMidSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowMidSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9ba400">
                          <SHORT-NAME>FasnSecRowMidSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowMidSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9bb700">
                          <SHORT-NAME>FasnSecRowMidSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowMidSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9bca00">
                          <SHORT-NAME>FasnSecRowRSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowRSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9bdd00">
                          <SHORT-NAME>FasnSecRowRSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowRSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9bf000">
                          <SHORT-NAME>FasnSecRowRSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnSecRowRSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c0300">
                          <SHORT-NAME>FasnThrdRowLSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowLSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c1600">
                          <SHORT-NAME>FasnThrdRowLSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowLSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c2900">
                          <SHORT-NAME>FasnThrdRowLSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowLSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c3c00">
                          <SHORT-NAME>FasnThrdRowMidSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowMidSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c4f00">
                          <SHORT-NAME>FasnThrdRowMidSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowMidSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c6200">
                          <SHORT-NAME>FasnThrdRowMidSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowMidSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c7500">
                          <SHORT-NAME>FasnThrdRowRSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowRSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c8800">
                          <SHORT-NAME>FasnThrdRowRSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowRSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9c9b00">
                          <SHORT-NAME>FasnThrdRowRSbltIndCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FasnThrdRowRSbltIndCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltIndCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c986c00">
                          <SHORT-NAME>FrtPsngAirbagDsblIndF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngAirbagDsblIndF_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagDsblIndF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c987b00">
                          <SHORT-NAME>FrtPsngAirbagEnbIndF</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngAirbagEnbIndF_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagEnbIndF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c988a00">
                          <SHORT-NAME>FrtPsngAirbagIndReq</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngAirbagIndReq_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagIndReq</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c989900">
                          <SHORT-NAME>FrtPsngAirbagSwSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngAirbagSwSts_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9cae00">
                          <SHORT-NAME>FrtPsngSbltAtc</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngSbltAtc_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtc</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9cc100">
                          <SHORT-NAME>FrtPsngSbltAtcV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FrtPsngSbltAtcV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtcV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d0b00">
                          <SHORT-NAME>FuCutReq_enum_FuCutReq_enum_FuCutReq_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FuCutReq_enum_FuCutReq_enum_FuCutReq_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFuCutReq_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b5700">
                          <SHORT-NAME>FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFulCutDMFPrdtn_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c9300">
                          <SHORT-NAME>FulCutEngStall_flg_FulCutEngStall_flg_FulCutEngStall_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FulCutEngStall_flg_FulCutEngStall_flg_FulCutEngStall_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFulCutEngStall_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8dfb00">
                          <SHORT-NAME>FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFulCutLosCommWthEMS_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ebe00">
                          <SHORT-NAME>HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_HCUSAMTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHCUSAMTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c900800">
                          <SHORT-NAME>IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_NKI_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NKI_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c90ad00">
                          <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_BSMtoRMS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c918e00">
                          <SHORT-NAME>IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOSSta_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c932300">
                          <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_NOStoRMS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c917f00">
                          <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c927e00">
                          <SHORT-NAME>IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMSSta_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c921500">
                          <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RMStoNOS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c91e800">
                          <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoNOS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c929c00">
                          <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NM_RSStoRMS_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c916100">
                          <SHORT-NAME>IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_NOI_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NOI_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c926f00">
                          <SHORT-NAME>IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_NWI_SFCANFD</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_SFCANFD_out</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_NWI_SFCANFD</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b9400">
                          <SHORT-NAME>ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IISGMaxTqLmt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8dec00">
                          <SHORT-NAME>ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_ISGMinTqLmt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IISGMinTqLmt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c6600">
                          <SHORT-NAME>ISGTqTgt_Nm_ISGTqTgt_Nm_ISGTqTgt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ISGTqTgt_Nm_ISGTqTgt_Nm_ISGTqTgt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IISGTqTgt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc0500">
                          <SHORT-NAME>LDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIO_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccbf300">
                          <SHORT-NAME>LDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIndLghtF_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb61600">
                          <SHORT-NAME>LHZCU_400ms_Group18_CRC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_CRC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3caefb00">
                          <SHORT-NAME>LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ILHZCU_400ms_Group18</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb62500">
                          <SHORT-NAME>LHZCU_400ms_Group18_RC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_RC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7a400">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved1_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7af00">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved2_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7ba00">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved3_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7c500">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved4_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7d000">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved5</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved5_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved5</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7db00">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved6</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved6_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved6</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cb7e600">
                          <SHORT-NAME>LHZCU_400ms_Group18_Reserved7</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_Group18_Reserved7_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved7</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e3700">
                          <SHORT-NAME>MONSAMTqReq_Nm_MONSAMTqReq_Nm_MONSAMTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/MONSAMTqReq_Nm_MONSAMTqReq_Nm_MONSAMTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMONSAMTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e0a00">
                          <SHORT-NAME>MONTMTqReq_Nm_MONTMTqReq_Nm_MONTMTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/MONTMTqReq_Nm_MONTMTqReq_Nm_MONTMTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMONTMTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98a800">
                          <SHORT-NAME>PedtrnProtnSysDplSts</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PedtrnProtnSysDplSts_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98b700">
                          <SHORT-NAME>PedtrnProtnSysDplStsV</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PedtrnProtnSysDplStsV_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplStsV</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98c600">
                          <SHORT-NAME>PedtrnProtnSysIndrCmd</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PedtrnProtnSysIndrCmd_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysIndrCmd</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b8500">
                          <SHORT-NAME>PwrDMd_enum_PwrDMd_enum_PwrDMd_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PwrDMd_enum_PwrDMd_enum_PwrDMd_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrDMd_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b6600">
                          <SHORT-NAME>PwrReq_flg_PwrReq_flg_PwrReq_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/PwrReq_flg_PwrReq_flg_PwrReq_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrReq_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc2900">
                          <SHORT-NAME>RDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIO_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc1700">
                          <SHORT-NAME>RDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIndLghtF_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc3b00">
                          <SHORT-NAME>RevsLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RevsLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtF_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc4d00">
                          <SHORT-NAME>RevsLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RevsLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtOn_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bee00">
                          <SHORT-NAME>Rolloff2Min_flg_Rolloff2Min_flg_Rolloff2Min_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/Rolloff2Min_flg_Rolloff2Min_flg_Rolloff2Min_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRolloff2Min_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c7500">
                          <SHORT-NAME>RolloffHld_flg_RolloffHld_flg_RolloffHld_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RolloffHld_flg_RolloffHld_flg_RolloffHld_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRolloffHld_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc5f00">
                          <SHORT-NAME>RrFogLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RrFogLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtF_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc7100">
                          <SHORT-NAME>RrFogLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RrFogLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtOn_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9ad300">
                          <SHORT-NAME>SDM_20ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9cd400">
                          <SHORT-NAME>SDM_20ms_Group01_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_CRC_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c9ce700">
                          <SHORT-NAME>SDM_20ms_Group01_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_RC_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cdd4c00">
                          <SHORT-NAME>SDM_20ms_Group01_Reserved1</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_Reserved1_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved1</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cdd5700">
                          <SHORT-NAME>SDM_20ms_Group01_Reserved2</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_Reserved2_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved2</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cdd6200">
                          <SHORT-NAME>SDM_20ms_Group01_Reserved3</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_Reserved3_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved3</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cdd6d00">
                          <SHORT-NAME>SDM_20ms_Group01_Reserved4</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group01_Reserved4_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved4</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c985d00">
                          <SHORT-NAME>SDM_20ms_Group02</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ISDM_20ms_Group02</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c992000">
                          <SHORT-NAME>SDM_20ms_Group02_CRC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_CRC_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c992f00">
                          <SHORT-NAME>SDM_20ms_Group02_RC</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_RC_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e90130c8a00">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved16</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved16_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved16</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e90130f5800">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved31</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved31_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved31</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e9013122b00">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved37</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved37_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved37</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e901314eb00">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved47_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e901317b600">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved51</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved51_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved51</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e90131d4b00">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved57</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved57_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved57</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f58e5e90131a8000">
                          <SHORT-NAME>SDM_20ms_Group02_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_Group02_Reserved63_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d6500">
                          <SHORT-NAME>SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_SOCLowPwrDwn_flg</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISOCLowPwrDwn_flg</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e2800">
                          <SHORT-NAME>SOCLvl_enum_SOCLvl_enum_SOCLvl_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SOCLvl_enum_SOCLvl_enum_SOCLvl_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISOCLvl_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d1a00">
                          <SHORT-NAME>SOCMd_enum_SOCMd_enum_SOCMd_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SOCMd_enum_SOCMd_enum_SOCMd_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISOCMd_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccb3600">
                          <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SeatOccptnNum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISeatOccptnNum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d9200">
                          <SHORT-NAME>ShftSeqStat_enum_ShftSeqStat_enum_ShftSeqStat_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ShftSeqStat_enum_ShftSeqStat_enum_ShftSeqStat_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IShftSeqStat_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8db000">
                          <SHORT-NAME>StrtTypAvail_enum_StrtTypAvail_enum_StrtTypAvail_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/StrtTypAvail_enum_StrtTypAvail_enum_StrtTypAvail_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrtTypAvail_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ddd00">
                          <SHORT-NAME>TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_TASSAMTqSplt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITASSAMTqSplt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8e7300">
                          <SHORT-NAME>TASTMTqSplt_Nm_TASTMTqSplt_Nm_TASTMTqSplt_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TASTMTqSplt_Nm_TASTMTqSplt_Nm_TASTMTqSplt_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITASTMTqSplt_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ced00">
                          <SHORT-NAME>TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCUIntvSAMTq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8f2700">
                          <SHORT-NAME>TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_TCUIntvTMTq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCUIntvTMTq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8ccf00">
                          <SHORT-NAME>TCUOpSt_enum_TCUOpSt_enum_TCUOpSt_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TCUOpSt_enum_TCUOpSt_enum_TCUOpSt_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCUOpSt_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccca700">
                          <SHORT-NAME>TDM_200ms_Group01_CRC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_CRC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_CRC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cccb900">
                          <SHORT-NAME>TDM_200ms_Group01_RC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_RC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_RC</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cced200">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved103</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved103_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved103</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccee300">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved111</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved111_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved111</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccef400">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved119</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved119_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved119</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccf0500">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved127</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved127_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved127</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce2800">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved15</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved15_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved15</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce3900">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved27</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved27_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved27</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce4a00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved39</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved39_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved39</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce5b00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved47</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved47_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved47</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce6c00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved55</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved55_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved55</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce7d00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved63</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved63_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved63</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce8e00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved71</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved71_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved71</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cce9f00">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved79</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved79_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved79</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3cceb000">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved87</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved87_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved87</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccec100">
                          <SHORT-NAME>TDM_200ms_Group01_Reserved95</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_Reserved95_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved95</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccbbd00">
                          <SHORT-NAME>TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ITDM_200ms_Group01</I-SIGNAL-GROUP-REF>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3caf0a00">
                          <SHORT-NAME>TPMSF_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TPMSF_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSF</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3caf1900">
                          <SHORT-NAME>TPMSTirePrsLowIO_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TPMSTirePrsLowIO_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSTirePrsLowIO</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bc100">
                          <SHORT-NAME>TQRTMTqReq_N_TQRTMTqReq_N_TQRTMTqReq_N</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TQRTMTqReq_N_TQRTMTqReq_N_TQRTMTqReq_N_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITQRTMTqReq_N</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8b0c00">
                          <SHORT-NAME>TRCEMTqReq_Nm_TRCEMTqReq_Nm_TRCEMTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TRCEMTqReq_Nm_TRCEMTqReq_Nm_TRCEMTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITRCEMTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bfd00">
                          <SHORT-NAME>TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITRCTqDmdSTC_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d5600">
                          <SHORT-NAME>TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITZXEMMaxTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8bb200">
                          <SHORT-NAME>TZXEMTqReq_Nm_TZXEMTqReq_Nm_TZXEMTqReq_Nm</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TZXEMTqReq_Nm_TZXEMTqReq_Nm_TZXEMTqReq_Nm_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITZXEMTqReq_Nm</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8c2a00">
                          <SHORT-NAME>TqCtrlStat_enum_TqCtrlStat_enum_TqCtrlStat_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TqCtrlStat_enum_TqCtrlStat_enum_TqCtrlStat_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITqCtrlStat_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc8300">
                          <SHORT-NAME>TrlrCnctSts_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TrlrCnctSts_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrlrCnctSts</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c8d8300">
                          <SHORT-NAME>VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVDCSlipCtrlSts_enum</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c98d500">
                          <SHORT-NAME>VehCrshTyp</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/VehCrshTyp_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehCrshTyp</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                        <I-SIGNAL-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3ccc9500">
                          <SHORT-NAME>VehSideLghtSts_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</SHORT-NAME>
                          <I-SIGNAL-PORT-REFS>
                            <I-SIGNAL-PORT-REF DEST="I-SIGNAL-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/VehSideLghtSts_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</I-SIGNAL-PORT-REF>
                          </I-SIGNAL-PORT-REFS>
                          <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSideLghtSts_TDM</I-SIGNAL-REF>
                        </I-SIGNAL-TRIGGERING>
                      </I-SIGNAL-TRIGGERINGS>
                      <PDU-TRIGGERINGS>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxN200000119f4464397e3358800">
                          <SHORT-NAME>ICBAD_100ms_PDU27</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/ICBAD_100ms_PDU27_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU27</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FCWSysFltSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FCWrnngSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c73c800">
                          <SHORT-NAME>LHZCU_400ms_PDU18</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/LHZCU_400ms_PDU18_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU18</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_CRC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_RC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved5</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved6</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LHZCU_400ms_Group18_Reserved7</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TPMSF_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TPMSTirePrsLowIO_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c71a000">
                          <SHORT-NAME>NmPDU_SFCANFD_IBS</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_IBS_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c71ab00">
                          <SHORT-NAME>NmPDU_SFCANFD_IPD</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_IPD_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_NKI_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_NOI_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_NWI_SFCANFD</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c72be00">
                          <SHORT-NAME>NmPDU_SFCANFD_PEU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_PEU_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c71b600">
                          <SHORT-NAME>NmPDU_SFCANFD_PICM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_PICM_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c71c100">
                          <SHORT-NAME>NmPDU_SFCANFD_RZCU</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_RZCU_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c71cc00">
                          <SHORT-NAME>NmPDU_SFCANFD_SDM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_SDM_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c735600">
                          <SHORT-NAME>NmPDU_SFCANFD_TDM</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/NmPDU_SFCANFD_TDM_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c721d00">
                          <SHORT-NAME>RZCU_100ms_PDU49</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RZCU_100ms_PDU49_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU49</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DsblICE_flg_DsblICE_flg_DsblICE_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DsblISG_flg_DsblISG_flg_DsblISG_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EVMd_flg_EVMd_flg_EVMd_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStallCnt_cnt_EngStallCnt_cnt_EngStallCnt_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStall_cnt_EngStall_cnt_EngStall_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_EngStrtFailCnt_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtFail_cnt_EngStrtFail_cnt_EngStrtFail_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/PwrDMd_enum_PwrDMd_enum_PwrDMd_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_SOCLowPwrDwn_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SOCLvl_enum_SOCLvl_enum_SOCLvl_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SOCMd_enum_SOCMd_enum_SOCMd_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/StrtTypAvail_enum_StrtTypAvail_enum_StrtTypAvail_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c73e100">
                          <SHORT-NAME>RZCU_10ms_PDU01</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU01</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c751200">
                          <SHORT-NAME>RZCU_10ms_PDU02</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU02</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c721100">
                          <SHORT-NAME>RZCU_10ms_PDU41</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/RZCU_10ms_PDU41_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU41</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ChrgPwrReq_kW_ChrgPwrReq_kW_ChrgPwrReq_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ChrgReq_flg_ChrgReq_flg_ChrgReq_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCFCOReq_flg_ERCFCOReq_flg_ERCFCOReq_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCHVAllwd_flg_ERCHVAllwd_flg_ERCHVAllwd_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCHVHldReq_flg_ERCHVHldReq_flg_ERCHVHldReq_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngBrkTqMax_Nm_EngBrkTqMax_Nm_EngBrkTqMax_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngFastTqReq_Nm_EngFastTqReq_Nm_EngFastTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngFastTqTypReq_enum_EngFastTqTypReq_enum_EngFastTqTypReq_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngPhsAng_deg_EngPhsAng_deg_EngPhsAng_deg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngSlowTqReq_Nm_EngSlowTqReq_Nm_EngSlowTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStopReqCfmd_flg_EngStopReqCfmd_flg_EngStopReqCfmd_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/EngStrtReq_flg_EngStrtReq_flg_EngStrtReq_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FuCutReq_enum_FuCutReq_enum_FuCutReq_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FulCutEngStall_flg_FulCutEngStall_flg_FulCutEngStall_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_HCUSAMTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_ISGMinTqLmt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ISGTqTgt_Nm_ISGTqTgt_Nm_ISGTqTgt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/MONSAMTqReq_Nm_MONSAMTqReq_Nm_MONSAMTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/MONTMTqReq_Nm_MONTMTqReq_Nm_MONTMTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/PwrReq_flg_PwrReq_flg_PwrReq_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/Rolloff2Min_flg_Rolloff2Min_flg_Rolloff2Min_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RolloffHld_flg_RolloffHld_flg_RolloffHld_flg</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/ShftSeqStat_enum_ShftSeqStat_enum_ShftSeqStat_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_TASSAMTqSplt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TASTMTqSplt_Nm_TASTMTqSplt_Nm_TASTMTqSplt_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_TCUIntvTMTq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TCUOpSt_enum_TCUOpSt_enum_TCUOpSt_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TQRTMTqReq_N_TQRTMTqReq_N_TQRTMTqReq_N</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TRCEMTqReq_Nm_TRCEMTqReq_Nm_TRCEMTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TZXEMTqReq_Nm_TZXEMTqReq_Nm_TZXEMTqReq_Nm</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TqCtrlStat_enum_TqCtrlStat_enum_TqCtrlStat_enum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c751d00">
                          <SHORT-NAME>RZCU_20ms_PDU06</SHORT-NAME>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_20ms_PDU06</I-PDU-REF>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c726200">
                          <SHORT-NAME>SDM_100ms_PDU03</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_100ms_PDU03_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_100ms_PDU03</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SeatOccptnNum</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c762400">
                          <SHORT-NAME>SDM_20ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_PDU01_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagDplForeCall</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagDplInvsneForeCall</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagSysFltForeCall</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DrvrSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/DrvrSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnDrvrSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnDrvrSbltIndCmdEvtTyp_SDM_20ms_Group01_SDM_20ms_Group01_SDM_20ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnFrtPsngSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSbltAudRmndr</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowLSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowLSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowLSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowMidSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowMidSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowMidSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowRSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowRSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnSecRowRSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowLSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowLSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowLSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowMidSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowMidSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowMidSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowRSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowRSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnThrdRowRSbltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngSbltAtc</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngSbltAtcV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_Reserved1</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_Reserved2</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_Reserved3</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group01_Reserved4</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c726d00">
                          <SHORT-NAME>SDM_20ms_PDU02</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/SDM_20ms_PDU02_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU02</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagDpl</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagDplInvsn</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagSysFlt</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/AirbagSysFltIndCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FMOccupntSts_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnFrtRowMidSbltAtcV_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnFrtRowMidSbltAtc_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FasnFrtRowMidSbltIndCmd_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngAirbagDsblIndF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngAirbagEnbIndF</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngAirbagIndReq</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/FrtPsngAirbagSwSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/PedtrnProtnSysDplSts</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/PedtrnProtnSysDplStsV</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/PedtrnProtnSysIndrCmd</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_CRC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_RC</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved16</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved31</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved37</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved51</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved57</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/SDM_20ms_Group02_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/VehCrshTyp</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                        <PDU-TRIGGERING UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c739900">
                          <SHORT-NAME>TDM_200ms_PDU01</SHORT-NAME>
                          <I-PDU-PORT-REFS>
                            <I-PDU-PORT-REF DEST="I-PDU-PORT">/Topology/HardwareComponents/IPD/IPD_SFCANFD/TDM_200ms_PDU01_IPD_SFCANFD</I-PDU-PORT-REF>
                          </I-PDU-PORT-REFS>
                          <I-PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TDM_200ms_PDU01</I-PDU-REF>
                          <I-SIGNAL-TRIGGERINGS>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/BrkLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/BrkLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/LDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RevsLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RevsLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RrFogLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RrFogLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_CRC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_RC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved103</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved111</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved119</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved127</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved15</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved27</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved39</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved47</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved55</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved63</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved71</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved79</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved87</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_Reserved95</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/TrlrCnctSts_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                            <I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                              <I-SIGNAL-TRIGGERING-REF DEST="I-SIGNAL-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/VehSideLghtSts_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01</I-SIGNAL-TRIGGERING-REF>
                            </I-SIGNAL-TRIGGERING-REF-CONDITIONAL>
                          </I-SIGNAL-TRIGGERINGS>
                        </PDU-TRIGGERING>
                      </PDU-TRIGGERINGS>
                    </CAN-PHYSICAL-CHANNEL>
                  </PHYSICAL-CHANNELS>
                  <CAN-FD-BAUDRATE>2000000</CAN-FD-BAUDRATE>
                </CAN-CLUSTER-CONDITIONAL>
              </CAN-CLUSTER-VARIANTS>
            </CAN-CLUSTER>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="b33f18816bc332a5aceb2656975eaa92">
          <SHORT-NAME>HardwareComponents</SHORT-NAME>
          <ELEMENTS>
            <ECU-INSTANCE UUID="Oa505a3f19f25843c4b3f8ef4XOa505a3f19f25843c4b3f8ef300">
              <SHORT-NAME>IPD</SHORT-NAME>
              <ASSOCIATED-COM-I-PDU-GROUP-REFS>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_BKPCANFD_Rx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_BKPCANFD_Tx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_CHCANFD_Rx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_CHCANFD_Tx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_PTCANFD_Rx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_PTCANFD_Tx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_SFCANFD_Rx</ASSOCIATED-COM-I-PDU-GROUP-REF>
                <ASSOCIATED-COM-I-PDU-GROUP-REF DEST="I-SIGNAL-I-PDU-GROUP">/Communication/PDUs/IPD_SFCANFD_Tx</ASSOCIATED-COM-I-PDU-GROUP-REF>
              </ASSOCIATED-COM-I-PDU-GROUP-REFS>
              <COMM-CONTROLLERS>
                <CAN-COMMUNICATION-CONTROLLER UUID="Oa505a3f19f25843c4b3f5af9XOa505a3f19f25843c4b3f5af800">
                  <SHORT-NAME>IPD_BKPCANFD1</SHORT-NAME>
                  <CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                    <CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                      <CAN-CONTROLLER-ATTRIBUTES>
                        <CAN-CONTROLLER-CONFIGURATION>
                          <CAN-CONTROLLER-FD-ATTRIBUTES>
                            <PROP-SEG>3</PROP-SEG>
                            <SYNC-JUMP-WIDTH>3</SYNC-JUMP-WIDTH>
                            <TIME-SEG-1>6</TIME-SEG-1>
                            <TIME-SEG-2>3</TIME-SEG-2>
                          </CAN-CONTROLLER-FD-ATTRIBUTES>
                          <PROP-SEG>5</PROP-SEG>
                          <SYNC-JUMP-WIDTH>2</SYNC-JUMP-WIDTH>
                          <TIME-SEG-1>7</TIME-SEG-1>
                          <TIME-SEG-2>2</TIME-SEG-2>
                        </CAN-CONTROLLER-CONFIGURATION>
                      </CAN-CONTROLLER-ATTRIBUTES>
                    </CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                  </CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                </CAN-COMMUNICATION-CONTROLLER>
                <CAN-COMMUNICATION-CONTROLLER UUID="Oa505a3f19f25843c4b3f5a75XOa505a3f19f25843c4b3f5a7400">
                  <SHORT-NAME>IPD_CHCANFD1</SHORT-NAME>
                  <CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                    <CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                      <CAN-CONTROLLER-ATTRIBUTES>
                        <CAN-CONTROLLER-CONFIGURATION>
                          <CAN-CONTROLLER-FD-ATTRIBUTES>
                            <PROP-SEG>3</PROP-SEG>
                            <SYNC-JUMP-WIDTH>3</SYNC-JUMP-WIDTH>
                            <TIME-SEG-1>6</TIME-SEG-1>
                            <TIME-SEG-2>3</TIME-SEG-2>
                          </CAN-CONTROLLER-FD-ATTRIBUTES>
                          <PROP-SEG>5</PROP-SEG>
                          <SYNC-JUMP-WIDTH>2</SYNC-JUMP-WIDTH>
                          <TIME-SEG-1>7</TIME-SEG-1>
                          <TIME-SEG-2>2</TIME-SEG-2>
                        </CAN-CONTROLLER-CONFIGURATION>
                      </CAN-CONTROLLER-ATTRIBUTES>
                    </CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                  </CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                </CAN-COMMUNICATION-CONTROLLER>
                <CAN-COMMUNICATION-CONTROLLER UUID="Oa505a3f19f25843c4b3f5ab7XOa505a3f19f25843c4b3f5ab600">
                  <SHORT-NAME>IPD_PTCANFD1</SHORT-NAME>
                  <CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                    <CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                      <CAN-CONTROLLER-ATTRIBUTES>
                        <CAN-CONTROLLER-CONFIGURATION>
                          <CAN-CONTROLLER-FD-ATTRIBUTES>
                            <PROP-SEG>3</PROP-SEG>
                            <SYNC-JUMP-WIDTH>3</SYNC-JUMP-WIDTH>
                            <TIME-SEG-1>6</TIME-SEG-1>
                            <TIME-SEG-2>3</TIME-SEG-2>
                          </CAN-CONTROLLER-FD-ATTRIBUTES>
                          <PROP-SEG>5</PROP-SEG>
                          <SYNC-JUMP-WIDTH>2</SYNC-JUMP-WIDTH>
                          <TIME-SEG-1>7</TIME-SEG-1>
                          <TIME-SEG-2>2</TIME-SEG-2>
                        </CAN-CONTROLLER-CONFIGURATION>
                      </CAN-CONTROLLER-ATTRIBUTES>
                    </CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                  </CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                </CAN-COMMUNICATION-CONTROLLER>
                <CAN-COMMUNICATION-CONTROLLER UUID="Oa505a3f19f25843c4b3f5cacXOa505a3f19f25843c4b3f5cab00">
                  <SHORT-NAME>IPD_SFCANFD1</SHORT-NAME>
                  <CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                    <CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                      <CAN-CONTROLLER-ATTRIBUTES>
                        <CAN-CONTROLLER-CONFIGURATION>
                          <CAN-CONTROLLER-FD-ATTRIBUTES>
                            <PROP-SEG>3</PROP-SEG>
                            <SYNC-JUMP-WIDTH>3</SYNC-JUMP-WIDTH>
                            <TIME-SEG-1>6</TIME-SEG-1>
                            <TIME-SEG-2>3</TIME-SEG-2>
                          </CAN-CONTROLLER-FD-ATTRIBUTES>
                          <PROP-SEG>5</PROP-SEG>
                          <SYNC-JUMP-WIDTH>2</SYNC-JUMP-WIDTH>
                          <TIME-SEG-1>7</TIME-SEG-1>
                          <TIME-SEG-2>2</TIME-SEG-2>
                        </CAN-CONTROLLER-CONFIGURATION>
                      </CAN-CONTROLLER-ATTRIBUTES>
                    </CAN-COMMUNICATION-CONTROLLER-CONDITIONAL>
                  </CAN-COMMUNICATION-CONTROLLER-VARIANTS>
                </CAN-COMMUNICATION-CONTROLLER>
              </COMM-CONTROLLERS>
              <CONNECTORS>
                <CAN-COMMUNICATION-CONNECTOR UUID="Oa505a3f19f25843c4b3b8ee6xOa505a3f19f25843c4b3b8f0600">
                  <SHORT-NAME>IPD_BKPCANFD</SHORT-NAME>
                  <COMM-CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_BKPCANFD1</COMM-CONTROLLER-REF>
                  <ECU-COMM-PORT-INSTANCES>
                    <I-SIGNAL-PORT UUID="c98279ee5ade3ba2b6fad9e5f64dbc97">
                      <SHORT-NAME>ACAmbtTemMsk_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91f2998a378e3492a62d29cd9bc11545">
                      <SHORT-NAME>ACAmbtTemV_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c72a488c2fa361395aa6ab872f5b789">
                      <SHORT-NAME>ACAmbtTem_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b27d94f838c3497ab9ec1605bf2a9bc">
                      <SHORT-NAME>ACCAccReqSts_CH_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c3b04ed1d203a02a5a629f7ec58f58a">
                      <SHORT-NAME>ACCAccReqToqVal_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d363979106c3f71aa925ed02c450547">
                      <SHORT-NAME>ACCAccReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6bb24fcd3c12320a9f75effe136df5ad">
                      <SHORT-NAME>ACCConfmSwReq_ACCConfmSwReq_ACCConfmSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21518f78ddb536bc8d0c409d074687ca">
                      <SHORT-NAME>ACCConfmSw_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="420207c63065311c9bcafeaf4ea266fa">
                      <SHORT-NAME>ACCCurveSpdSwReq_ACCCurveSpdSwReq_ACCCurveSpdSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="914ec792e54a39a2b945cb8e24104a37">
                      <SHORT-NAME>ACCCurveSpdSw_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab9794991a9135c3890acd67d4df02b8">
                      <SHORT-NAME>ACCDetObj1ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d39d56b8918354db34448cb4b764f8c">
                      <SHORT-NAME>ACCDetObj1Id_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72adc4f2043f3d3887130a07116f8cd5">
                      <SHORT-NAME>ACCDetObj1LatRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c86cd59366423d838903e62927ed67e7">
                      <SHORT-NAME>ACCDetObj1LongtRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="62d22b9ceb2433fc8919cce72db6e686">
                      <SHORT-NAME>ACCDetObj1LongtRltvSpd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4296f1b1a7f734a4a8df35abb909bef3">
                      <SHORT-NAME>ACCDetObj1Risk_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f62c731514d232dcb05a4d8821a67632">
                      <SHORT-NAME>ACCDetObj1SyncCtr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31afe529b2e837078208a7c6aef3c040">
                      <SHORT-NAME>ACCDetObj1Typ_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12ffc7d29d9a34c8880a72fd263dc407">
                      <SHORT-NAME>ACCDetObj2ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3acbeedc89203c649a97491217d03c5f">
                      <SHORT-NAME>ACCDetObj2Id_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cba56dcda8d43572ab1687ca2a5e8660">
                      <SHORT-NAME>ACCDetObj2LatRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="450955d9fd293618893ad984d36856cb">
                      <SHORT-NAME>ACCDetObj2LongtRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24f4fc077cdc3d04a5e423e6bda338c8">
                      <SHORT-NAME>ACCDetObj2LongtRltvSpd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77cc8aecfb7d3ed686372f2837ce35ad">
                      <SHORT-NAME>ACCDetObj2Risk_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="490c337f0e2c378f950a1252ee49a11f">
                      <SHORT-NAME>ACCDetObj2SyncCtr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f5914e9398335e89f692d9f3d2e5370">
                      <SHORT-NAME>ACCDetObj2Typ_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="027f70f38b9f338589d7223dc052b433">
                      <SHORT-NAME>ACCDetObj3ExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="674658f2305f357781bfa374adf02c35">
                      <SHORT-NAME>ACCDetObj3Id_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7171814d3aa332f7aad25b8e7f992e03">
                      <SHORT-NAME>ACCDetObj3LatRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="85eacb4b87e73d2fb79a55fceac8e367">
                      <SHORT-NAME>ACCDetObj3LongtRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8cc102dd69d73f57b37f9fb70b63512a">
                      <SHORT-NAME>ACCDetObj3LongtRltvSpd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="01fe5463640831b2b7222857080c66ee">
                      <SHORT-NAME>ACCDetObj3Risk_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5e662c05364e377e9dffb34016636e42">
                      <SHORT-NAME>ACCDetObj3SyncCtr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83475adcd8373cdba1f9bfdc5ea382ae">
                      <SHORT-NAME>ACCDetObj3Typ_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e81ee27becb13769b5e83489a808b96b">
                      <SHORT-NAME>ACCDetObjDistLvl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="71516e126938322db167150ecac75738">
                      <SHORT-NAME>ACCDetObjExistPrblty_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="03a6fdef13dd311ba5954d9f45fbb720">
                      <SHORT-NAME>ACCDetObjHdngAng_ACCDetObjHdngAng_ACCDetObjHdngAng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5048a5a75433069a28317e5dc79581d">
                      <SHORT-NAME>ACCDetObjId_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="061b311831243f5a902ebf6ce9e4a669">
                      <SHORT-NAME>ACCDetObjLatRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bc12a10f81b23ce6b8cc957e74b85c67">
                      <SHORT-NAME>ACCDetObjLongtRltvDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2bfaaa9c1dfe3c30bdd51a359477c060">
                      <SHORT-NAME>ACCDetObjLongtRltvSpd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="051903fc958039c89fde01dd358c63ff">
                      <SHORT-NAME>ACCDetObjRisk_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee464da306bb3fba8ef9b38f94cc4c4a">
                      <SHORT-NAME>ACCDetObjSyncCtr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a0255da58773fcd899bfea91adab157">
                      <SHORT-NAME>ACCDetObjTyp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d3c92a6b618239c6a543ac52707a5e6e">
                      <SHORT-NAME>ACCDrvrSelTrgtSpd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a14a010ce9e335ebadf80869087c824b">
                      <SHORT-NAME>ACCDrvrTkovReq_ACCDrvrTkovReq_ACCDrvrTkovReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47f36f55e9d3379687a997a8cf0f8aa4">
                      <SHORT-NAME>ACCGoNotfr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e26c5be5ed436a8b3bc632bd4e4c3b6">
                      <SHORT-NAME>ACCGoReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="194eaed515ac3e47adfebc172f581098">
                      <SHORT-NAME>ACCMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fce6b9950b083e17977d2b40817c036a">
                      <SHORT-NAME>ACCObjDet_ACCObjDet_ACCObjDet_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7949fdcfc4ed372d8c592e13a33aef0a">
                      <SHORT-NAME>ACCSdslReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4aec8e2cfab3768886df3def0befe5a">
                      <SHORT-NAME>ACCSeldTrgtDistLvl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="92aa3775aeec3649828bfea1e2cafc3c">
                      <SHORT-NAME>ACCSpdLimtSwReq_ACCSpdLimtSwReq_ACCSpdLimtSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bca4761b0df130b9ae3e57c6db940c51">
                      <SHORT-NAME>ACCSpdLimtSw_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="abb7e8fe6c2f3492b6f080d8d2b54e8d">
                      <SHORT-NAME>ACCStsSwReq_ACCStsSwReq_ACCStsSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="391bb082c65b39638d18c463e5fe9977">
                      <SHORT-NAME>ACCStsSw_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1382d15d75ab36648c22157175ea287f">
                      <SHORT-NAME>ACCSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="721687c876023e52a3c4c4d24fbdde3d">
                      <SHORT-NAME>ACCSysFltSts_SCS_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf5d6509614e3c44a9afdfc86181c0ae">
                      <SHORT-NAME>ACCSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d7baf779a0e3381840e6cba091e1124">
                      <SHORT-NAME>ACCTJAMdSwDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75b42d2da6e63e63a9c4a444defbd91e">
                      <SHORT-NAME>ACCTJAMdSwReq_ACCTJAMdSwReq_ACCTJAMdSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7f9c97633ef3250b098eccffc20a32c">
                      <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="acc6630c7d143244a855ef85e03671b4">
                      <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e669e06d330b3dcaa3721faa50a88a5a">
                      <SHORT-NAME>ACCTotWhlToqReqSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9f8077dadc833de8a5f00cc5453375a3">
                      <SHORT-NAME>ACCTotWhlToqReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6010d0c2b2d332e2bfebb3820ce5badf">
                      <SHORT-NAME>ACComprActuPwr_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d2288a6656c39fab000bda85b9ffdbe">
                      <SHORT-NAME>ADAudioSWReq_ADAudioSWReq_ADAudioSWReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9503fdc012f326bae21deea193a562f">
                      <SHORT-NAME>ADAudioSWSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3803f9ae381c32fc9f7dd89beacdeb30">
                      <SHORT-NAME>ADS_ISAMsgReq_ADS_ISAMsgReq_ADS_ISAMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="40dba414fd8a335b8653ec0033b29712">
                      <SHORT-NAME>ADS_ISASysFltSts_ADS_ISASysFltSts_ADS_ISASysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39dc56de033f353ea654aaf423780fac">
                      <SHORT-NAME>ADS_ISASysSts_ADS_ISASysSts_ADS_ISASysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3885ffb61a4c348f9514f65c375e347e">
                      <SHORT-NAME>AEBBrkJerkLvlReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e1b9bef8825c3fdda6533f35d01b41d4">
                      <SHORT-NAME>AEBDclReqSts_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50bb24adfe9f3974a2084ffa48c9e378">
                      <SHORT-NAME>AEBDclReqSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d5c0aa4738431e190f904f0a1ac85f8">
                      <SHORT-NAME>AEBDclReqToqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a42141500123b08b47a12633de8fbb6">
                      <SHORT-NAME>AEBDclReqToqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8ea0b0bd57c32d3a31f68384d1fd666">
                      <SHORT-NAME>AEBDclReqVal_ADAS_RFSDA_20ms_Group02_RFSDA_20ms_Group02_RFSDA_20ms_Group02_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9de549306aeb31cb8d55f5112d42b96b">
                      <SHORT-NAME>AEBDclReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="762f289f489e30e5bf51e416d4d2b64b">
                      <SHORT-NAME>AEBDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13ed09cc782a3614bdd79ad2b9e27f27">
                      <SHORT-NAME>AEBHydBrkAstLvlReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5721a44e77013ab1bc35123cdf1e5d11">
                      <SHORT-NAME>AEBMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d05d29be0ac33b68707516de3a3e6b0">
                      <SHORT-NAME>AEBPrflReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d1038b73d5e3dd0817c592f49dd009f">
                      <SHORT-NAME>AEBSwReq_AEBSwReq_AEBSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b1d3ddf12e0314c88bb84f62fa9d0b3">
                      <SHORT-NAME>AEBSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13e1763ce9393e40a55ba1b15010756e">
                      <SHORT-NAME>AEBSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e19505018a42384881fec05f8b1fd8e0">
                      <SHORT-NAME>AIParkngDsp_AIParkngDsp_AIParkngDsp_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d00bd6185d6c3d3aa349e5fd75b071a4">
                      <SHORT-NAME>AIParkngEPAMdsts_AIParkngEPAMdsts_AIParkngEPAMdsts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1a07164011c345f8dc652cfa1036583">
                      <SHORT-NAME>AIParkngEPAMdsw_AIParkngEPAMdsw_AIParkngEPAMdsw_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="568cb349d2dd366783cc18c49453af67">
                      <SHORT-NAME>AIParkngReqICB_AIParkngReqICB_AIParkngReqICB_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a77dfa2bcd59396cadb3e31d12d02c93">
                      <SHORT-NAME>AIParkngReq_AIParkngReq_AIParkngReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="554c9db13cb93d67a72616079b03c21f">
                      <SHORT-NAME>AIParkngReq_ZXD_AIParkngReq_ZXD_AIParkngReq_ZXD_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="046ad34d5e673496972c204898791c39">
                      <SHORT-NAME>AIParkngRespICB_AIParkngRespICB_AIParkngRespICB_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fec14e32c0aa3894b0c5ae5b2de9b765">
                      <SHORT-NAME>AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_AIParkngSSPLotSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4039c10fdb683ba39765c053c5f4c0f6">
                      <SHORT-NAME>AIParkngSSPLotSw_AIParkngSSPLotSw_AIParkngSSPLotSw_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a31e277457031e0b5b5a2d1ce0f6232">
                      <SHORT-NAME>AIParkngSpcID_AIParkngSpcID_AIParkngSpcID_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4fca065803e3312a97b48ebfde49a524">
                      <SHORT-NAME>AIParkngSpdsw_AIParkngSpdsw_AIParkngSpdsw_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a68b625c563e30ba83d96252d0718a8a">
                      <SHORT-NAME>AIParkngSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f09d33d39c4a3544a2f03f5af243a10b">
                      <SHORT-NAME>AIPilotIntervQuit_AIPilotIntervQuit_AIPilotIntervQuit_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e1c1db5c61d83fd39e3cad1cc5f815c4">
                      <SHORT-NAME>AIPkgAPASCSAcclReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="979f6cd001663b29be9efd31980cc15e">
                      <SHORT-NAME>ALCSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd42aa714ad1335986e6fcbb20ff7e05">
                      <SHORT-NAME>ALCSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ebb15b1f50c635809e2966597c9ee6ad">
                      <SHORT-NAME>AMRPrtensonReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e716941867833cc3bfe46ed69fd39d15">
                      <SHORT-NAME>APACmdEPSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d5c5a7f23083facbce26b16387072b7">
                      <SHORT-NAME>APACrpSpdReqVal_IPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="212c3c404bc8328da6b456eeeda5c619">
                      <SHORT-NAME>APAEPBOPReqV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9f64ef0b595837c8854ec7680af511a6">
                      <SHORT-NAME>APAEPBOPReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c12eb4676a463f93984555dcb14b5dd8">
                      <SHORT-NAME>APAEnRunReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04c207c8f1713d1dac8c14fac3b70554">
                      <SHORT-NAME>APAF_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ad0ee7ccad653b588c7bff41d8059415">
                      <SHORT-NAME>APAOneKeyParkSwReq_APAOneKeyParkSwReq_APAOneKeyParkSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51e45b9a16e23302b9b0425f9c950ff2">
                      <SHORT-NAME>APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_APAParkInOffsetTypeReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="63835cb8c6d43528adc6980ad53a8449">
                      <SHORT-NAME>APAParkInOffsetType_APAParkInOffsetType_APAParkInOffsetType_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf9f2e310f573e2a9bd7f4d3efe039f5">
                      <SHORT-NAME>APARemShifGear_APARemShifGear_APARemShifGear_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="64b4978d990b3d5e9eacd3c15bfd6393">
                      <SHORT-NAME>APARevrDrgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24935ef7615430e2b61f554fa5011b2c">
                      <SHORT-NAME>APASCSAcclReqSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae8072524d5032c5af3dc4e275c44f66">
                      <SHORT-NAME>APASCSToqReqVal_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d85e67d509a5357ea68f5818f39a4635">
                      <SHORT-NAME>APASCUReqStsV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="927b6a94c54939ed915e7a6a101f282f">
                      <SHORT-NAME>APASCUReqSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22d6d797ecbb3884a6f8bc407d64fad3">
                      <SHORT-NAME>APASWReq_APASWReq_APASWReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e9e3be5a6e6d3362a1602647184b4ecc">
                      <SHORT-NAME>APASW_APASW_APASW_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="368fc01a4f8133f98c35e266e9edbe10">
                      <SHORT-NAME>APAShifterPosReqdV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="180f476db4e934eea4c285ec5dfb0a3e">
                      <SHORT-NAME>APAShifterPosReqd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e4e8a60bccb633dd92b98f5832b4533f">
                      <SHORT-NAME>APASpdMdSwSts_APASpdMdSwSts_APASpdMdSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="393f26950f9937029b2935033047ace1">
                      <SHORT-NAME>APASts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="23b08f7ddbb03a52b116601f13498e3e">
                      <SHORT-NAME>APAToqReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="021a81b5d7643baca5fade3e48c6002b">
                      <SHORT-NAME>APATotWhlToqReqVal_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae35ca8419883f288ca371dd8573c69f">
                      <SHORT-NAME>APATrgtEPSStrgWhlAng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="325abfe91cf732118ebe160edbcda125">
                      <SHORT-NAME>APAVCUReqSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fce733b9e0a2393da3359efeb674d467">
                      <SHORT-NAME>APAVehCrdnatAzmth_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="10d65bf8b835347ba9e9beb3e7ccacea">
                      <SHORT-NAME>APAVehCrdnatPosX_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="552164cebf3036ad9ff2cbc21d9ccbc8">
                      <SHORT-NAME>APAVehCrdnatPosY_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d052f121fb4d3e6d8dea7c8f9119fe5d">
                      <SHORT-NAME>AVMDspReq_AVMDspReq_AVMDspReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a48190fd08bf37cfad689985c53fdbac">
                      <SHORT-NAME>AVMSt_AVMSt_AVMSt_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2f414667c32e3d90a6aa70649c3a2e37">
                      <SHORT-NAME>AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_AVPMapRutMgIDtReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ea8b6e361743e559ec7403f8f3a438c">
                      <SHORT-NAME>AltSigma_IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e9d8adc059943382a21cf43ce7f616f1">
                      <SHORT-NAME>AltitudeRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9b1092d91893b2999312b5ec16e43d2">
                      <SHORT-NAME>AutoLaneChngLLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="656b585219253389a7568024c06a7872">
                      <SHORT-NAME>AutoLaneChngMsgReq_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da5fe490e9da325eb41243e5528b64c1">
                      <SHORT-NAME>AutoLaneChngRLaneSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c9354453ae733089b7fb15b2ca318e2">
                      <SHORT-NAME>AutoLaneChngSetReq_AutoLaneChngSetReq_AutoLaneChngSetReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec816726b165385ab163fca20af8953e">
                      <SHORT-NAME>AutoLaneChngSetResp_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1e456295c08316684cbbd4d18ea69ab">
                      <SHORT-NAME>AutoLaneChngSwDspCmd_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6744aea7ca3539e2ba1148854e033077">
                      <SHORT-NAME>AutoLaneChngSwReq_AutoLaneChngSwReq_AutoLaneChngSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb21a704ee0b34b3b617ad2aa784bec1">
                      <SHORT-NAME>AutoLaneChngVcCmd_AutoLaneChngVcCmd_AutoLaneChngVcCmd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27b94b96cbc63dd9a8cbdfc08c90920d">
                      <SHORT-NAME>AutoMainBeamLghtOn_AutoMainBeamLghtOn_AutoMainBeamLghtOn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e4e2d62069a33b2a589b0c0a7972aa0">
                      <SHORT-NAME>AutoMainBeamLghtReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="659eb9e47de334729e93f809c926474f">
                      <SHORT-NAME>AutocParkngSwReq_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7fdeb317e483d979f5edd1847549ef3">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReqV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97b4f3455d16303fbe29d770bd1ec2e4">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81ef5a483f7931a5852afec44de972d9">
                      <SHORT-NAME>AutodDrvngSysFlrStsV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f1aa9edca5734149969db2801db9090">
                      <SHORT-NAME>AutodDrvngSysFlrSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9915884f60323892b217eb086c5dd8a4">
                      <SHORT-NAME>AutodDrvngSysMdReqV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="90b6e874af2d336890908917bf91f986">
                      <SHORT-NAME>AutodDrvngSysMdReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3b7a8655368a3fa49447cc55696a7be9">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e914a1971af6345cadf05f06b7ee6a9c">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d5c21aa9ede93ec883a04d5e9f8e7f70">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReqV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97c82a5a358731388195aec93b916b5f">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39b3cd26b67a31b591eb1c942e4f004e">
                      <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="78270c83e4913a178f2f885afaed6d4a">
                      <SHORT-NAME>AutodDrvngSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="e0a9199d3152351fb7b3003c73bee555">
                      <SHORT-NAME>BCM_100ms_PDU41_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="370c9042f14c350597a1327a4bc53fb5">
                      <SHORT-NAME>BCM_BDCAN_100ms_FrP41_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="73df1f24e2773a74852246a83f0072f2">
                      <SHORT-NAME>BPMMstrAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b3643d4d65e23a948659995844bec062">
                      <SHORT-NAME>BSDSelReq_BSDSelReq_BSDSelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fade0ee17d53c8f81b06b3db866c55e">
                      <SHORT-NAME>BSDSelSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="93a0694390f03e2293bbe6835a7a918c">
                      <SHORT-NAME>BaseLineLen_BaseLineLen_BaseLineLen_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6618ddf2a04a392bba0b0831e81a7ad6">
                      <SHORT-NAME>BntOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f7da517c238391aa8b66300135f9eb6">
                      <SHORT-NAME>BrkLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0c75372c2713200b51dd4aa320bfff7">
                      <SHORT-NAME>BrkLghtFltSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d756809d25573f7f82fe8a7d7e56b4b3">
                      <SHORT-NAME>BrkLghtFltSts_HW_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c541260b5477340f95a65eb0eb7b10b3">
                      <SHORT-NAME>BrkLghtSta_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="366c6cb1f8da38269d2f792787311d05">
                      <SHORT-NAME>BrkLghtSts_HW_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ff1dc408bd73e8ab4d1aa974d779e6b">
                      <SHORT-NAME>BrkLghtSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="acad0838c4333c93afcff024ae27997e">
                      <SHORT-NAME>CANprotocolinternalversion_CANprotocolinternalversion_CANprotocolinternalversion_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="93af65be42b63692a0fd981f4c28f348">
                      <SHORT-NAME>CCDisAdjtVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2ffc489d51c36af9038a829a2cb4051">
                      <SHORT-NAME>CCDisDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a0774670b8a313a84cd1e864806797e">
                      <SHORT-NAME>CCSpdDecAndIncVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65937ff01cc53db5861917c3008d2d71">
                      <SHORT-NAME>CCSpdVcCmdCnfm_CCSpdVcCmdCnfm_CCSpdVcCmdCnfm_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d1cdf6ba1eb35eb81c6cbd46cebfd84">
                      <SHORT-NAME>CCSpdVcCmdSwReq_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04ee07f900833614ab0164e1426d095e">
                      <SHORT-NAME>CCSpdVcCmd_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7a5d35f59c73ca19048c4ebf80e9d0f">
                      <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1dcf88648167357da12825b2c1f03ba8">
                      <SHORT-NAME>CCSwStsCCASwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8cbdee8f1ab0310f9f123a4351b05a38">
                      <SHORT-NAME>CCSwStsCanclSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b5e9eefc28933f98b5dc0bb96de03a5">
                      <SHORT-NAME>CCSwStsDistDecSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88ec1c4ec685394bbdca143d411d604c">
                      <SHORT-NAME>CCSwStsDistIncSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cc0c3d67a7013f5e949fccded628c2c3">
                      <SHORT-NAME>CCSwStsOnSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b16302542a3f3fedb10f5eb15a8137f4">
                      <SHORT-NAME>CCSwStsRsmSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ea4b9018bdf3d2cbb02528405fd4181">
                      <SHORT-NAME>CCSwStsSetSwA_ICBVC_50ms_Group158_ICBVC_50ms_Group158_ICBVC_50ms_Group158_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4442e9184715302280026d3a03e14698">
                      <SHORT-NAME>CCSwStsSpdDecSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5343c37aaf4326090d1a23ecf66dfa3">
                      <SHORT-NAME>CCSwStsSpdIncSwA_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8f8797d91273ea8a6901a1e4178f9b3">
                      <SHORT-NAME>CCSwStsSwDataIntgty_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c7269fc54a6c34f28d856b2e8c739483">
                      <SHORT-NAME>ChrgrFlapLtchCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b61735dbbe89352a84aee794a6df2224">
                      <SHORT-NAME>ClstrDspdAirbagWrnng_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cec4b2df913f31fb9341dc665bbdd96c">
                      <SHORT-NAME>ClstrDspdVehSpd_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8a2c079e550b358db86e11a4e8017364">
                      <SHORT-NAME>ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_ClstrDspdVehSpd_mph_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4418fffc64b1371b83a530e7082646e5">
                      <SHORT-NAME>ComKeyEnbReq_ComKeyEnbReq_ComKeyEnbReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="67dfdd42ff9737538044352befe4473d">
                      <SHORT-NAME>D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_D2DPriETClanSwReqResps_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b3900d92c1b430a38e9a62236f18a0c2">
                      <SHORT-NAME>D2DPriETClanSwReq_D2DPriETClanSwReq_D2DPriETClanSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d7a360fdc643ab4afd74904b65d3a39">
                      <SHORT-NAME>D2DSwReqResps_D2DSwReqResps_D2DSwReqResps_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50a1b3a3b9f23b228163c6fc5b965ead">
                      <SHORT-NAME>D2DSwReq_D2DSwReq_D2DSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8a002d9c9eab3f2fac948f78e478df33">
                      <SHORT-NAME>D2DSysSts_D2DSysSts_D2DSysSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="c20995b31c4c33818ab36bfa62253194">
                      <SHORT-NAME>DIAG_BKPCANFD_FuncReq_SDU_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="853eacf9e46b3ff49e5f763010533532">
                      <SHORT-NAME>DIAG_BKPCANFD_PhyReq_IPD_SDU_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ab4301d49ed13678b10124f1f77dd6be">
                      <SHORT-NAME>DIAG_BKPCANFD_PhyResp_IPD_SDU_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="564de465eddd3b5aad660e61945aa769">
                      <SHORT-NAME>DIAG_DTCInfo_ICBAD_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="51f4d1e5a4123b248cc66bc7a43829fe">
                      <SHORT-NAME>DIAG_DTCInfo_ICBAD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="16bf24cb680a3b6f9699e9196b1917a7">
                      <SHORT-NAME>DILampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="a37a394f5ba236ddbe091cfaaae7a97d">
                      <SHORT-NAME>DKMM_LHBDCANFD_Event_FrS03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="7e79aeac32a332c2a82a8fbb8db1ad78">
                      <SHORT-NAME>DKMM_Sporadic_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="cff3eabcfa2e3c19af08e673f8f5625a">
                      <SHORT-NAME>DMSCameraFps_IMM_DMSCameraFps_IMM_DMSCameraFps_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9af6591f7e03c0e85820d02bb6b4c4f">
                      <SHORT-NAME>DMSSts_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c3ade254ebd36d6864bda9043d61509">
                      <SHORT-NAME>DOWSelReq_DOWSelReq_DOWSelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be9dbdbb7c9233f8b26aab984776045d">
                      <SHORT-NAME>DOWSelSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c12afce5c2fa394292beb61b1b621a84">
                      <SHORT-NAME>DTCInfomationIPD_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9aa4a1d2004a34369c195147021b62ec">
                      <SHORT-NAME>DetourMsgReq_DetourMsgReq_DetourMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e78e8fa3c743793acfbc104f6e175f7">
                      <SHORT-NAME>DfstOnDspCmd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="01b2a6ed00e33cf98f4df9f18ec1a623">
                      <SHORT-NAME>Diag_BKPCANFD_FuncReq_BKPCANFD_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="4582d021bafa3927b7bfea382fe0ac22">
                      <SHORT-NAME>Diag_BKPCANFD_FuncReq_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="499f2c65fe8a32be81b8a533b78d51c0">
                      <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD_BKPCANFD_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="265e9de033e0310a94e8174aa79ee5d2">
                      <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="72656ec11a1c32d19bec3226e18c5ad1">
                      <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD_BKPCANFD_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="a59062f1c6e03ccd9092d16946a0bf98">
                      <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="e46f5665da1b390180da9a911110b258">
                      <SHORT-NAME>DiffAgeInfo_DiffAgeInfo_DiffAgeInfo_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="237bc71521093858be346de28a1a6f33">
                      <SHORT-NAME>DiffDataLinkBroken_DiffDataLinkBroken_DiffDataLinkBroken_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b307b754b859323a816d7859460300fd">
                      <SHORT-NAME>DigKeyAuthReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6d11607aa54385d85aba5b0db49b3e8">
                      <SHORT-NAME>DigKeyPEValidReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="870c0b8ccde03bb89b6bb24528783f0a">
                      <SHORT-NAME>DippedBeamActStatus_LHZCU_20ms_Group03_LHZCU_20ms_Group03_LHZCU_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1d9c5206a51538a9a949413fe79789a4">
                      <SHORT-NAME>DircnIndLampSwStsMntry_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="952b49d03f29338c9db754473e412782">
                      <SHORT-NAME>DircnIndLghtMdSts_DircnIndLghtMdSts_DircnIndLghtMdSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5818c4fba8213a2e9af6f388f719e0cd">
                      <SHORT-NAME>DircnIndLghtSwSts_DircnIndLghtSwSts_DircnIndLghtSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f03f19dfac4932cf9969e59d10ecc224">
                      <SHORT-NAME>DircnLghtFltsts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="004be3cc13cb3835b69c19610aaa708a">
                      <SHORT-NAME>DircnLghtMdSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be31a211d23e35cfaa34fecc7329467a">
                      <SHORT-NAME>DircnLghtOnReq_LHZCU_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="906f9debfde730c888150574befc43b7">
                      <SHORT-NAME>DircnLghtSts_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f3a7b6a3a2235399e401bafe29f464b">
                      <SHORT-NAME>DircnLghtSwReq_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02d1b7e463fe33cdbab117fb8d7dbb06">
                      <SHORT-NAME>DirnLghtSftyMonErr_LHZCU_50ms_Group06_LHZCU_50ms_Group06_LHZCU_50ms_Group06_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0a4b1b875c436adbda0b4f1800545e4">
                      <SHORT-NAME>DistSinceTrgtCamr_DistSinceTrgtCamr_DistSinceTrgtCamr_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f41541c284b33cada08e3b82ea528a87">
                      <SHORT-NAME>DistToTrfcJamNav_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="877a65e954a43d37b1d33afa454dda3c">
                      <SHORT-NAME>DownVelocityRTK_DownVelocityRTK_DownVelocityRTK_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1495c3bae8d53af6bebee80c8d506703">
                      <SHORT-NAME>DrvrAbnormBehvor_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="984f99e7d5fa3eebb8738c9132c8b02d">
                      <SHORT-NAME>DrvrAbnormConf_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6cfa1f8dc2633cc8ae36248f6db31be2">
                      <SHORT-NAME>DrvrDetSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="329fe7ac653a3153b326c74213bae4d0">
                      <SHORT-NAME>DrvrDoorOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de52b5d6c2fb39879bfacf1d51dbb4de">
                      <SHORT-NAME>DrvrDstcnConf_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="564fb0ca83ec3f409f96a54c47dd3764">
                      <SHORT-NAME>DrvrDstcnStsINST_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04e6b7335a283fc6993bc55991646194">
                      <SHORT-NAME>DrvrDstcnSts_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83a4726043c93ca1b691308804be974b">
                      <SHORT-NAME>DrvrDstrctnSts_DrvrDstrctnSts_DrvrDstrctnSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0fc2d1c83a2e335dba78f98e7706ab67">
                      <SHORT-NAME>DrvrFtgConf_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e8c51ef35863ca4a48463fe97c58c22">
                      <SHORT-NAME>DrvrFtgLvlINST_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bdeddc86d4cf3966ba00078f6125f2a7">
                      <SHORT-NAME>DrvrFtgLvl_DrvrFtgLvl_DrvrFtgLvl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="623c2b05c4ff304cbfbbbf067f3caea4">
                      <SHORT-NAME>DrvrFtgLvl_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6aaa8b2c8e0c3dc9aa30e15bf6fbb139">
                      <SHORT-NAME>DrvrGazeRgn_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cbfb105bb37b3c328c6231250adb4e56">
                      <SHORT-NAME>DrvrPrst_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b17694838ed338fa416226e2a13f5af">
                      <SHORT-NAME>DrvrReqGearShftPosInvs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f27184dfe7b03514b4340e20562e6511">
                      <SHORT-NAME>DrvrReqGearShftPos_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ec46708ba2e3c1b9e5f45d4c32379b6">
                      <SHORT-NAME>DrvrReqParkBtn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8623a88669ec326b86af13a10ceae310">
                      <SHORT-NAME>DspMeasmtSys_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9f088f6d07d350b92d6e828cac2db79">
                      <SHORT-NAME>ELKDspCmd_ELKDspCmd_ELKDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="09b83b7a6a913328b5815569c579839d">
                      <SHORT-NAME>ELKSwReq_ELKSwReq_ELKSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4bd365cb3d3b3dcdb0c563576514747d">
                      <SHORT-NAME>ELKSysFltSts_ELKSysFltSts_ELKSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dab94b3a82a23af08d0cca7945918c9a">
                      <SHORT-NAME>ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7af8a98767263e6fbdb95b1253aef87c">
                      <SHORT-NAME>ELKWarning_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e31e7675661a3a3e854860a558a07b03">
                      <SHORT-NAME>EORWarningEvtSts_EORWarningEvtSts_EORWarningEvtSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c90ff71c0cbb324fb295d11cdc8d6d25">
                      <SHORT-NAME>EPSAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49c81763f4a93e609dd6ec015ac57552">
                      <SHORT-NAME>EPTNotReadyReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a0e90a213d235cbb1eeb4865ff36cd0">
                      <SHORT-NAME>ESCLPwrSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4125f59f2519323fa998e9f0a60fc310">
                      <SHORT-NAME>ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_ESSAdoWrnngDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7aa14b49bf193a24b63d341665f5a5c6">
                      <SHORT-NAME>ESSAdoWrnngReq_ESSAdoWrnngReq_ESSAdoWrnngReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52423abf3d5838eab44e5ecf327bccb0">
                      <SHORT-NAME>ESSDirInd_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7aa64a5b0b0a3f63ab6bcbbcd5cb3bc3">
                      <SHORT-NAME>ESSDrvrTkovReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4584e2e8c4031eebd925770725d9d15">
                      <SHORT-NAME>ESSDspCmd_ESSDspCmd_ESSDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="00afaaca5e4c3733afb037dc889a20e8">
                      <SHORT-NAME>ESSSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9457bd5677d73ff28cf4208f01373285">
                      <SHORT-NAME>ESSSysSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c58e596fce7b3382ae34ce4616cd31a1">
                      <SHORT-NAME>ESSswReq_ESSswReq_ESSswReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e766083dc2cc3270a6a919cc28947bcb">
                      <SHORT-NAME>EastVelocityRTK_EastVelocityRTK_EastVelocityRTK_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="33234b7b556536e3ad52449acc1d3845">
                      <SHORT-NAME>ElecPwrDistbnScene_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37520479d2253778aa1dc0c597952790">
                      <SHORT-NAME>EleccTrRngReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d399c1b5ab8f35cc961847b7f2b4abe9">
                      <SHORT-NAME>En12VoltStrMotCmddOn_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c05a4e814b1636f795247cc110e8bea3">
                      <SHORT-NAME>EvtPotclSigIPD1_EvtPotclSigIPD1_EvtPotclSigIPD1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c46018905726381eae089ec947ed186f">
                      <SHORT-NAME>EvtPotclSigIPD2_EvtPotclSigIPD2_EvtPotclSigIPD2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5ed62ef784f3b73814e955a2827c097">
                      <SHORT-NAME>EvtPotclSigIPD3_EvtPotclSigIPD3_EvtPotclSigIPD3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e70285d7fa63eb8b0025ca0ca61494f">
                      <SHORT-NAME>EvtPotclSigIPD4_EvtPotclSigIPD4_EvtPotclSigIPD4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3869e7eaf5943d1ab2cfd6eb8096576c">
                      <SHORT-NAME>EvtPotclSigIPD5_EvtPotclSigIPD5_EvtPotclSigIPD5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24f219700cac3204a12a953c35edce12">
                      <SHORT-NAME>EvtPotclSigIPD6_EvtPotclSigIPD6_EvtPotclSigIPD6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2132f895a02a37e282ae8269863fa6ca">
                      <SHORT-NAME>EvtPotclSigIPD7_EvtPotclSigIPD7_EvtPotclSigIPD7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="836dc988336436c59963f91834b6552c">
                      <SHORT-NAME>EvtPotclSigIPD8_EvtPotclSigIPD8_EvtPotclSigIPD8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="25dbcfa899463af084b01650784f33e1">
                      <SHORT-NAME>EyeGazepitch_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbf18ce7fe393f8fb76d70dbc75f00b4">
                      <SHORT-NAME>EyeGazeyaw_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="557cb424b3793490a55cfdc665915f5c">
                      <SHORT-NAME>EyeOffRoadDetnStaV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8292922da1e93ced92173cca375de6eb">
                      <SHORT-NAME>EyeOffRoadDetnSta_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a71fef33826832ad85d52ed31a71396c">
                      <SHORT-NAME>EyeOnRoad_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="125da1b131853d69ba9acb049ba09e37">
                      <SHORT-NAME>EyeOpenDegree_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9269e327ab73e90b5001ff566447dc3">
                      <SHORT-NAME>EyeOpenStatus_IMM_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="63abb70191d331398ffc753e0932a7fc">
                      <SHORT-NAME>FCTBSysFltSts_ADAS_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="add4d8fd7425343f961b31dd0665ca68">
                      <SHORT-NAME>FCTBSysFltSts_FCTBSysFltSts_FCTBSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f5d1657035b3b3c9881c3a1bd44698e">
                      <SHORT-NAME>FCTSwSts_ADAS_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d5baee03ec793eb089ffc3bd35b50da2">
                      <SHORT-NAME>FCTSwSts_FCTSwSts_FCTSwSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="61660dc8f16233a2807f6b4955688bef">
                      <SHORT-NAME>FCTSysFltSts_ADAS_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0fbccdfbbff3f8780042bfa4fb86098">
                      <SHORT-NAME>FCTSysFltSts_FCTSysFltSts_FCTSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee6f1ad33f9a3d9aa9a9ed8545ad682f">
                      <SHORT-NAME>FCTSysSelReq_FCTSysSelReq_FCTSysSelReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f8a47deb5813db8b7e6b2b5f1c20a0e">
                      <SHORT-NAME>FCWDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4dcc9d2a92537ef81d74ad03b991890">
                      <SHORT-NAME>FCWSnstvtLvlReq_FCWSnstvtLvlReq_FCWSnstvtLvlReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04665d36bd1e35aca5bf267ddccf58f4">
                      <SHORT-NAME>FCWSnstvtLvl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="233eadbd518c35ddabea15ef05a5ae60">
                      <SHORT-NAME>FCWSwReq_FCWSwReq_FCWSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d75c73f84443c799c3c60b91f8e7b46">
                      <SHORT-NAME>FCWSysFltSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66b4c1f089313551b37766d662a5e01e">
                      <SHORT-NAME>FCWrnngSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2108f2b1d2f43ce0ba711a27e8070fe1">
                      <SHORT-NAME>FDRPwrSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ef7c94bb7613291bfa62ec5c757aeec">
                      <SHORT-NAME>FDRSts_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c161f37898f32d1a5781673e0d481fc">
                      <SHORT-NAME>FDR_100ms_Group01_CRC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb7af3f63eec347e97fa241410611be2">
                      <SHORT-NAME>FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1e0a8c47c41a35e9a2e4b8c4bcdb6121">
                      <SHORT-NAME>FDR_100ms_Group01_RC_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1c53022c1d3355ca820424d96fd6b75">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved1_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84b8e94a2f143ca0a6d7a4021823807d">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved2_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d95a9b35a12a367d87e85eaa4ecaa6f8">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved3_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b211fb2a58023628a8ab1dfe9fd6efc6">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved4_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="71a6defe0a273549bdfd0a65e2b85376">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved5_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8c0a5138c2f3a3dae6bd5379eed9ee7">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved6_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27a4b7cf898330a7926147582150d6d5">
                      <SHORT-NAME>FDR_100ms_Group01_Reserved7_FDR_100ms_Group01_FDR_100ms_Group01_FDR_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="a121c9dfd9fc3bcb8d9c49a131ea0bd3">
                      <SHORT-NAME>FDR_100ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="f4c93d4ef02931c9843e2f99a76cbf75">
                      <SHORT-NAME>FDR_BKPCANFD_100ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2d6ee4625f8e3a3ebd8ce2c4d70ff46f">
                      <SHORT-NAME>FDR_BKPCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="f8277a8c13b639e1b42943d0c2e5c8a9">
                      <SHORT-NAME>FLDircnLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="698a1507e377301284e677589fee1f8b">
                      <SHORT-NAME>FLDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="436a3b7cfc7c33c898a13cc9634c4c0b">
                      <SHORT-NAME>FLDircnLghtSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83d6ae06551f3af395d1b3bf07bed95d">
                      <SHORT-NAME>FLDoorHndlPESwtActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="925694601f5936759281d1bbccbec984">
                      <SHORT-NAME>FLDoorOpenSts_FLDoorOpenSts_FLDoorOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ac9c3ded78f322eb45a0ae626affe3c">
                      <SHORT-NAME>FLObsRng_FLObsRng_FLObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7697655d529a322e9802f0393ecb506e">
                      <SHORT-NAME>FLSObsRng_FLSObsRng_FLSObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a97b2ebace53362ca6f80ca9856b79cb">
                      <SHORT-NAME>FLSUSSSts_FLSUSSSts_FLSUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab636dce98113b13a650f9045c94fb4a">
                      <SHORT-NAME>FLSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1598fe3e12b03624910d05ed49f96505">
                      <SHORT-NAME>FLSeatHorzPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd5bf9eb19a53644925c194666e29b7b">
                      <SHORT-NAME>FLSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b58dadf29c84392c8f7c0b3692f05d64">
                      <SHORT-NAME>FLSeatVertPos_LHZCU_100ms_Group30_LHZCU_100ms_Group30_LHZCU_100ms_Group30_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b59aa7b24b153bda8aa836b9e656b3b0">
                      <SHORT-NAME>FLSideObsRng_FLSideObsRng_FLSideObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ccbec1237d4635f8826a1d8379e061da">
                      <SHORT-NAME>FLTirePrsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cdde8b336dc73b5fae0e950be6d1f7ab">
                      <SHORT-NAME>FLTirePrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69c64fcd81ee3337916269eca41b27fd">
                      <SHORT-NAME>FLTireSts_FLTireSts_FLTireSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2afd77808eb235a581fbf52b98930a8e">
                      <SHORT-NAME>FLTireTemV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b56d7eea4513e3da9e3f15f17385615">
                      <SHORT-NAME>FLTireTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="863890d7198431aea683845590f6cf51">
                      <SHORT-NAME>FLUSSSts_FLUSSSts_FLUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="934eb5ee768f3520b83e2befc694ac4a">
                      <SHORT-NAME>FLiDARPwrSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e82f30b045be3fbda3a7c4bba0f47044">
                      <SHORT-NAME>FMLUSSSts_FMLUSSSts_FMLUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f3c948a8f6a3c6e8cfb1cf12b376bc7">
                      <SHORT-NAME>FMRUSSSts_FMRUSSSts_FMRUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6d55882b8b63dcb9f61616f674d2f42">
                      <SHORT-NAME>FOTAStatusValid_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d28d1d242de3300aa854abb8fdf9833b">
                      <SHORT-NAME>FOTAStatus_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0c8ba02283c3ceba4c3ef8ce3c759dc">
                      <SHORT-NAME>FOTATargetValid_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="42a2445f5f963aebb89a1a5aa204b1a7">
                      <SHORT-NAME>FOTATarget_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa0d9bd8d49c3330a9020c482488fbef">
                      <SHORT-NAME>FRDircnLghtCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5569e9648cb8307a84667cfe56c2979f">
                      <SHORT-NAME>FRDircnLghtFltsts_ICBVC_50ms_Group13_ICBVC_50ms_Group13_ICBVC_50ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d61c7cc329f37189c9549374972ad55">
                      <SHORT-NAME>FRDircnLghtSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="791344d374b93e7db8502fdd46b19e70">
                      <SHORT-NAME>FRDoorHndlPESwtActv_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa14db60703534bb94649d0dcb784b57">
                      <SHORT-NAME>FRDoorOpenSts_FRDoorOpenSts_FRDoorOpenSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ebc9ac52eddc3d64b6b1c62e3b71a45d">
                      <SHORT-NAME>FRObsRng_FRObsRng_FRObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8fe1ccae4c7430878f61e51112647665">
                      <SHORT-NAME>FRSObsRng_FRSObsRng_FRSObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2f6bcda992f3da8adbae800ee3f30b8">
                      <SHORT-NAME>FRSUSSSts_FRSUSSSts_FRSUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="643a4d598fcc35fbbe60c3227e0d60eb">
                      <SHORT-NAME>FRSeatHeatCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e21f2e7fa3d3432983d02c6135bafd8">
                      <SHORT-NAME>FRSeatHorzPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d46f7fc64d23bd9a754b240714d19fe">
                      <SHORT-NAME>FRSeatVentCtrlSts_ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f69f6a036ffb3011a4c00026fe369664">
                      <SHORT-NAME>FRSeatVertPos_RHZCU_100ms_Group10_RHZCU_100ms_Group10_RHZCU_100ms_Group10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59448fe39673305f8e78ea822a44af98">
                      <SHORT-NAME>FRSideObsRng_FRSideObsRng_FRSideObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fe88250eab0837b6928f4e2aae341693">
                      <SHORT-NAME>FRTirePrsV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9d48e75eb94337bb1a0468eaa85f4f3">
                      <SHORT-NAME>FRTirePrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a37e5c7fe4dd382d9d506131d7dab5b3">
                      <SHORT-NAME>FRTireSts_FRTireSts_FRTireSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="07f4f03f224238ea87670582f47628dc">
                      <SHORT-NAME>FRTireTemV_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef300b4023ef313a83e8b804134b2ea7">
                      <SHORT-NAME>FRTireTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e55ef89763cf3477ae29b7978a50a2a1">
                      <SHORT-NAME>FRUSSSts_FRUSSSts_FRUSSSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="672de2392b1d3db2a2b5d2549f48ea62">
                      <SHORT-NAME>FVCM_100ms_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ff67604b2eb33a3c95b97c0337a8a09c">
                      <SHORT-NAME>FVCM_100ms_PDU05_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="318c08ff352333e0a2613aa2d2b2d36f">
                      <SHORT-NAME>FVCM_20ms_Group02_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8233519f63a23dadb9f15dfb2219cfbf">
                      <SHORT-NAME>FVCM_20ms_Group02_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="80a45320ac4736b5821f75aee4b9bb85">
                      <SHORT-NAME>FVCM_20ms_Group02_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9312712f5883629b48711cfab251cd1">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb0fb12e64143627968662cc0373ff0f">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b924dc26a5563f8ba07fe29beac8b74a">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5e439d18e99b34b5b067a0d43f666dc7">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="389bf403eada3180851d30429db94025">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f39dcd18010a3c37b8880b8ecddfcd08">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6aa3c4d87dbd335ca20875386101765a">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a2298f0643e73aa8b6c9830db3e2c6b1">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="9d95c51971143168a804345c3b532fa1">
                      <SHORT-NAME>FVCM_20ms_PDU02_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="2305bdd2fd32351f84451cf0f9ee0337">
                      <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="12615da3b73138f4b02b01e9f5c21215">
                      <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="97173edc8dd43eba8ce3845cd8ad5b32">
                      <SHORT-NAME>FVCM_BKPCANFD_20ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="88db65ffa7753bdd879f4f493792a9e8">
                      <SHORT-NAME>FixType_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b32d70485f96344ea594a6c838adaffb">
                      <SHORT-NAME>FrSsdManuCtrl_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2e8079717d0532579e14b37cd0d4cb3d">
                      <SHORT-NAME>FrtCamrHeatCtrl_FrtCamrHeatCtrl_FrtCamrHeatCtrl_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9adbe32faa3c3fe494bc3505d72fc429">
                      <SHORT-NAME>FrtCamrHeatSts_FrtCamrHeatSts_FrtCamrHeatSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d3b540c392935aa87098ad5be9ee69d">
                      <SHORT-NAME>FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_FrtCarGoNotfrDspCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c37ce86a131033898f90609b82d079a4">
                      <SHORT-NAME>FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_FrtCarGoNotfrSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="453dd29fbea23f1fa01daffb95dfd8c1">
                      <SHORT-NAME>FrtCarGoNotfr_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f747c077525031958073a2c3055c3d7f">
                      <SHORT-NAME>FrtMidLObsRng_FrtMidLObsRng_FrtMidLObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="751eafef49993dc7add4bc197210bf1e">
                      <SHORT-NAME>FrtMidRObsRng_FrtMidRObsRng_FrtMidRObsRng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8ade114a76039ac9cbb7dad9a26d642">
                      <SHORT-NAME>FrtObsDist_FrtObsDist_FrtObsDist_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31757560479a394bbb8550982b61c72c">
                      <SHORT-NAME>FrtPDCAudWrnng_FrtPDCAudWrnng_FrtPDCAudWrnng_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c90e54685af93e08bc42233f1b580c77">
                      <SHORT-NAME>FrtPsngAirbagSwStsReqV_Sfty_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="301401da6f55316f9b5cc48c14f6a6f6">
                      <SHORT-NAME>FrtPsngAirbagSwStsReq_Sfty_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd417f2017343d08b5aefe1a5bcd6e85">
                      <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53d16a5d6d5c3e96b7d0f15b46aaa590">
                      <SHORT-NAME>FrtTireStdPrs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f9dee13259933359569cd5ff9c0361b">
                      <SHORT-NAME>FrtWindShldSfcTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d51593bec513aea82384725448ab536">
                      <SHORT-NAME>FrtWindShldSurndHmdty_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f28d62d4dabc381e84b5fc2db7fe998f">
                      <SHORT-NAME>FrtWindShldSurndTem_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6cb29ec6fc963099abada7803f0d2283">
                      <SHORT-NAME>FrtWiperSpd_FrtWiperSpd_FrtWiperSpd_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bbb7cde35d49364d9fa8ab1bb3c0a121">
                      <SHORT-NAME>FrtWiperSwSts_FrtWiperSwSts_FrtWiperSwSts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5cb4156b6eec3054ae169b2e4cc04553">
                      <SHORT-NAME>GNSSAntennasBroken_GNSSAntennasBroken_GNSSAntennasBroken_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0cd844867da53f21a5b10dccd76b7b04">
                      <SHORT-NAME>GNSSAntennasInfo_GNSSAntennasInfo_GNSSAntennasInfo_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bcc8b796a81e3ce49ea20bb96153aa3c">
                      <SHORT-NAME>GNSSF9HCounter_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="160d624346c6349fa101f5e5c3214f3c">
                      <SHORT-NAME>GNSSSeq_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a19e70c4cd7436e89185d0e1f64a4962">
                      <SHORT-NAME>GNSSUTCTimeH_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e89a29251df63aa59c6cb1308ad0ad7e">
                      <SHORT-NAME>GNSSUTCTime_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="388324a334d336e8bed140c6ab81cb56">
                      <SHORT-NAME>HMISafFltsts_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2581e6a683de374cb4a5fd0b723c1d76">
                      <SHORT-NAME>HORWarningEvtSts_HORWarningEvtSts_HORWarningEvtSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e8bdfa0ca11347eb936d32284facbf9">
                      <SHORT-NAME>HPPFnSts_HPPFnSts_HPPFnSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0a5c9a7eb673e4f85fc88c5ecc5c7bf">
                      <SHORT-NAME>HPPInBmtSts_HPPInBmtSts_HPPInBmtSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b051974753223b8e8f95e31c5bd1625e">
                      <SHORT-NAME>HPPMapBuildSts_HPPMapBuildSts_HPPMapBuildSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75c212f9c5bb3842aef9b06751a034aa">
                      <SHORT-NAME>HPPOnRoutSts_HPPOnRoutSts_HPPOnRoutSts_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="61fa043dd2f9337798eb44ae1425f3ee">
                      <SHORT-NAME>HUDLkngAmbtLghtLvlByLux_LHZCU_50ms_Group24_LHZCU_50ms_Group24_LHZCU_50ms_Group24_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9bd44b64f5313ba6ad9ef9f8c306210d">
                      <SHORT-NAME>HandOffStrgWhlDetnStaV_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5582e1dc762d37148023bc7380d6681a">
                      <SHORT-NAME>HandOffStrgWhlDetnSta_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a5c34777144324c93955b942a8afa5c">
                      <SHORT-NAME>Hdop_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6419d35e829030ada2e226ecd64f31d8">
                      <SHORT-NAME>HeadingRTK_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de5b2cd0a7bd33d4ba867f27e72bf189">
                      <SHORT-NAME>HeadingSigma_IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="386d892260a534b69dd40550e28de5a4">
                      <SHORT-NAME>HmdtySnsrHdwrFltPrst_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae367da5bd2f367eb058a77b63b61878">
                      <SHORT-NAME>HzrdLampsCtrl_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="08615aa47cc73a4a851e0eb0d9d6e636">
                      <SHORT-NAME>HzrdLghtSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a1d390ee8cb83392b3d765794660048e">
                      <SHORT-NAME>IACCOvTSuppresCmd_IACCOvTSuppresCmd_IACCOvTSuppresCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c93835d362b0398c9fc21d872cd1be06">
                      <SHORT-NAME>IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IACCOvTSuppresSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2767be624cbd342f9a9ce22bb4595c08">
                      <SHORT-NAME>IACCPreMsgReq_IACCPreMsgReq_IACCPreMsgReq_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94d1999d910c31faadd397dfde4b4ed5">
                      <SHORT-NAME>IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IACCPreSpdLimtCmd_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="748ff527d10b3705907ef1c41b5c4774">
                      <SHORT-NAME>IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IACCPreSpdLimtSwReq_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24e5664ba058360dbd3ace78d5f25776">
                      <SHORT-NAME>IAMAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1590a2df596233d6be10e99cbe5d2511">
                      <SHORT-NAME>IAMReststs_IAMReststs_IAMReststs_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d7775da12ae03393ad583ea2282de4f7">
                      <SHORT-NAME>IAM_100ms_Group08_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a991535d17e63c67bc0d8864f00dd32b">
                      <SHORT-NAME>IAM_100ms_Group08_IAM_100ms_Group08_IAM_100ms_Group08_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b058d25e53e347aa6fc462b825f8341">
                      <SHORT-NAME>IAM_100ms_Group08_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="721a8a18e88f3d83851ae659a7e686b7">
                      <SHORT-NAME>IAM_100ms_Group08_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="366e7374f53935a1b08d6bbd1961508e">
                      <SHORT-NAME>IAM_100ms_Group18_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e2289fab72b34faa0402aa997f35271">
                      <SHORT-NAME>IAM_100ms_Group18_IAM_100ms_Group18_IAM_100ms_Group18_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8ecb7db6eb03d81863cb16b4f005ee2">
                      <SHORT-NAME>IAM_100ms_Group18_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff5ef5a2ee4930e683e582cec1e028cf">
                      <SHORT-NAME>IAM_100ms_Group18_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2ce3a320f003068a7d0df5317f06f8b">
                      <SHORT-NAME>IAM_100ms_Group56_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c89f0f5bff3f34898e6a296d9357b97f">
                      <SHORT-NAME>IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef896512cae33e2fb29cd52c0dc585fc">
                      <SHORT-NAME>IAM_100ms_Group56_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab7c5a1a6aa93f67aa78e60e52e2884d">
                      <SHORT-NAME>IAM_100ms_Group56_Reserved13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="563c919fa78230098fac62f910724e71">
                      <SHORT-NAME>IAM_100ms_Group56_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="d3106e16472b37288b63d91a391c2143">
                      <SHORT-NAME>IAM_100ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="0da3d46d22f53eb99c45a32d216d6e75">
                      <SHORT-NAME>IAM_100ms_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="808f039ced0e34c596d95cb410bcce24">
                      <SHORT-NAME>IAM_100ms_PDU06_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="bfa8fe3d9f3633e69600521fd3d13a33">
                      <SHORT-NAME>IAM_100ms_PDU07_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="495c28b34c01352ebc9bade4e6ef620b">
                      <SHORT-NAME>IAM_100ms_PDU08_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="92be5d60eb6a397795ee147ff2c4e65f">
                      <SHORT-NAME>IAM_100ms_PDU18_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="9322e364b3d83ae3953984992fd30c80">
                      <SHORT-NAME>IAM_100ms_PDU21_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="f3f7d94b0b8330c690d421fdd35f0885">
                      <SHORT-NAME>IAM_20ms_Group32_CRC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ead3642bb89e337bb3cd4a8616f32230">
                      <SHORT-NAME>IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="60882ac40ad235f38a246a63bc1a2f85">
                      <SHORT-NAME>IAM_20ms_Group32_RC_IAM_20ms_Group32_IAM_20ms_Group32_IAM_20ms_Group32_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d6a8e542eb913cd483f75c243e0f2b69">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved10_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="968ecb01a16b370abaf121f091fcdfde">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df0a95488163336394de7fd9e8f9f578">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="740508e7f7753fc493d58d408d2b27f0">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1a1eeb2317439d6a0e5eb5147d32916">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c27005818ea368bb668240b63e5faf9">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved5_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ddfc4c1e840b312ebe915bcfda41825c">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved6_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c36b03f4c8dc3c9ab435f77b8a13a01f">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved7_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7f510ccf326036f4a5017a9ac9f61f0c">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved8_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b54a2d9292f632758e7eaea8fe91b2ee">
                      <SHORT-NAME>IAM_20ms_Group32_Reserved9_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="6167b5e7e3a83fb492f63572ebb71ec7">
                      <SHORT-NAME>IAM_20ms_PDU32_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="ca3e6ed2cf1b340387181691853472f7">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP49_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="dc3a4f987c30332f872860d86e721f6f">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP55_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2475c2eaf92b375486004011df619377">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP58_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9136e56fda6f3006b5e4a4797237997a">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP59_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9c0926d1c2ef3f3592e8fbe817d8d31d">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP60_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="092eaaeb62cc3170986c685588b9fb49">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP61_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="682ecbd8392732ba95b84887097a43e6">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP62_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="79654836c1b7382588b469b695ab654a">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP63_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0e2b4917dd923ebf9cfab9314c21ef70">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP64_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c35c32ceeeba35c7a5e34ab07b9a1ef0">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP65_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="fb2259a1ecd030bfb03950f03c871fd8">
                      <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP66_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="3ba0996053b1331d8edfb0eb7e2dee85">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6248d0c601b33505ab25945ff2053160">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4b047c3dde483ee28d03ebe91365c9d4">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="623edd8ee3ad3f8993c96a7d57c07acd">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c8d3febd5f1a3bb890a1ba745d6e75a2">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP34_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="12f8c6e5920332bf87fd731e465fb8c5">
                      <SHORT-NAME>IAM_CONNCANFD_100ms_FrP40_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="869c3f5977e438da83796c0c549f0f05">
                      <SHORT-NAME>IAM_CONNCANFD_20ms_FrP32_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2af6878dfaf135648607259d1367e105">
                      <SHORT-NAME>IAM_CONNCANFD_Event_FrS04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="3da7c48ad95733cbaba3a2cea7081358">
                      <SHORT-NAME>IAM_CONNCAN_100ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="856700944c0c3dd0a772e85f699a6eb4">
                      <SHORT-NAME>IAM_CONNCAN_100ms_FrP18_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="171fd2b845ad314ca8941cc7b125575d">
                      <SHORT-NAME>IAM_CONNCAN_100ms_FrS21_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="c358ae22440a38d1ab75cccc24cc7d73">
                      <SHORT-NAME>IAM_GNSS_Signal_Status_IAM_100ms_Group56_IAM_100ms_Group56_IAM_100ms_Group56_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="987971516adf351ca2c75f20254b36cd">
                      <SHORT-NAME>IAM_RHBKBCANFD_100ms_FrP57_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="89af1d8e49c63fcba9ad1cbbce4c8ed1">
                      <SHORT-NAME>IAM_RZCUCANFD_100ms_FrP35_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="039251fb36d13de0be5a8130cb31b941">
                      <SHORT-NAME>IAM_Sporadic_PDU04_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5f7033a3337a3b6b9c6f2675fd0b6644">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU49_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f10d7b9e34493cb9904ae0600e9a3fbb">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU55_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="24bf6e8ca89c3ecfb23313ea8e0cd596">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU58_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8ae5eff8bb663debb4418d4d78313819">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU59_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="59515696a7ee3590afb0bc085aa45e62">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU60_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="26273275fd1536758629e9b1ec7942d8">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU61_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="0cdc00935b613475850775df16d984e1">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU62_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="60cafeabdd9a388b8af357ed8af4d631">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU63_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3626ee5c50233571b2ba67d8c1026140">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU64_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3cc246f10035321da0481490cf9703a5">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU65_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f22df67f78fe3f33a83957087d73d970">
                      <SHORT-NAME>IAM_ZONE_1000ms_PDU66_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="2d97355b3eeb3ac69d7953332983ca45">
                      <SHORT-NAME>IAM_ZONE_100ms_Group13_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9a56b3c33133bcab1646af853c12ae3">
                      <SHORT-NAME>IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IAM_ZONE_100ms_Group13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="369b7050cb3136b980e0411b05786987">
                      <SHORT-NAME>IAM_ZONE_100ms_Group13_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5a5ea765d1d3777a7eadebae2c51cf9">
                      <SHORT-NAME>IAM_ZONE_100ms_Group13_Reserved13_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="614ca89aa05e3bf1a938bd8531076ce8">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68a9f53c707d3afd95bdf17f0ec85b57">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IAM_ZONE_100ms_Group34_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a26860b0832936838ad8e9ef8683cc22">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="71c5ddc3184930d893dfec46c8480b2f">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9629aa3564ff3e749b2cb1bd57608eb7">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved23_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="762625426f013230a9cbc52a84e77315">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved39_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c0a48fd38c9303c80c4c84a1a4c03e2">
                      <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved55_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="32423803dd2f3aceb2abd32c8b48435f">
                      <SHORT-NAME>IAM_ZONE_100ms_Group35_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="11e08d548a82345e93291faee4ffa201">
                      <SHORT-NAME>IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IAM_ZONE_100ms_Group35_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f36f41d57a4233348c1f0e26cb7e8434">
                      <SHORT-NAME>IAM_ZONE_100ms_Group35_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5bbdbaa320773ebc9fcf650570ece685">
                      <SHORT-NAME>IAM_ZONE_100ms_Group35_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e027ae9766f93fcb8dec0ac9405b281f">
                      <SHORT-NAME>IAM_ZONE_100ms_Group40_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e45e77685e9c3a2b9b8ae0f318ab8108">
                      <SHORT-NAME>IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IAM_ZONE_100ms_Group40_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a31f4c5faefb355ea7af38fc2478b6c5">
                      <SHORT-NAME>IAM_ZONE_100ms_Group40_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b0ad0af10563abfb87919a55dcc219f">
                      <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c1af7e28e5a34889be8d2dcd94e3705">
                      <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f7f9140e75c63d65be0b8f4b657e8793">
                      <SHORT-NAME>IAM_ZONE_100ms_Group57_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="715d98ff1c063c12b2445c8bc8f971d6">
                      <SHORT-NAME>IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IAM_ZONE_100ms_Group57_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d68c146073c38d4930e2572484a462b">
                      <SHORT-NAME>IAM_ZONE_100ms_Group57_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="907d57f237c538a9857c4a20b965c4b3">
                      <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved15_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3bef4ed5f98b3e69841df4902ba3d24e">
                      <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="e1432101d2b639a889a162faa2303786">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU13_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="83f35c5999ba331088439773d68d2bbe">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU34_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d683bbca37703eada26c81820b6990b5">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU35_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b839891104943f3daef6f953219bb5f0">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU40_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="161d461c9c2a36758d3b3993eef79bf2">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU56_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="470ccf6e6c483c7ba293463c8749a73b">
                      <SHORT-NAME>IAM_ZONE_100ms_PDU57_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="a5142b4b3f173d8c806a4422cbcc924b">
                      <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="818ab08d7ba433b9a74d01b75d049634">
                      <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP56_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="9e5a5c4100d93b8091d001a640ce5748">
                      <SHORT-NAME>IBS_CHAvlbly_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4069c861f6c3e3d983bf11276e87116">
                      <SHORT-NAME>ICBAD_100ms_Group25_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2aade6766c5b300382055d760dd9fe8b">
                      <SHORT-NAME>ICBAD_100ms_Group25_ICBAD_100ms_Group25_ICBAD_100ms_Group25_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="738dbf816a643c2aa60a4867269c31b2">
                      <SHORT-NAME>ICBAD_100ms_Group25_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8bd21657912c3b1486a1b4a6bf7218e6">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved103_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89108a4ad5f731adb85c9fcdcfbf6edf">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved111_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7a69302fe1230189a2df12c28667370">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved119_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae697cab657b313ea0b47e74c39ace46">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved127_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7eb3f25a9a453d238252aff9d06974cd">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved135_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d75bb1113242397182b8c314f1620830">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved143_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fd0070f5d53f3a38830d4d8efac609ee">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved151_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="238a874869f43dd7b2977f444a037e88">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved159_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bb1009c638c13e019243a2a2b38e17e1">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved15_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26945699c7743303900da30f172a14e8">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved167_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="763b63d4090b3280b33ea3cfaba01190">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved175_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf06868f353630ea9624488b7f864057">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved183_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a4821d6bb16364c9f09374988028d77">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved191_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec2fb7ce444a34ee9553fea7e469c106">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved23_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8de893db062c343c82b554e13fa85d63">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved31_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df6d71da33423e9fa7ef1cc33e6e0b8d">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved39_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ee8efda7d2932508962273c13b69756">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved47_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be077bec1a6f323e8163bb17a0eb49f6">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved55_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8cfa58b93493c839a34200966ef01c3">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved63_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="60c7fce942e937599631721bcb77c375">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved71_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fb16eb058efa358eb80049ec679319d4">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved79_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a3f5a842c25c38dc84ba83157eea3753">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved87_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee23c42a71ed3bb8899d7ac59e0b0928">
                      <SHORT-NAME>ICBAD_100ms_Group25_Reserved95_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be369079cad53150a651cf9660e2dca6">
                      <SHORT-NAME>ICBAD_100ms_Group37_CRC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2be674c3d0a439fd9d3dd6d6c23762cd">
                      <SHORT-NAME>ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="533b9ee59f0d3dee84bc5f8720f23d08">
                      <SHORT-NAME>ICBAD_100ms_Group37_RC_ICBAD_100ms_Group37_ICBAD_100ms_Group37_ICBAD_100ms_Group37_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6485d5ac287a38b99c15eb0938046360">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b99ef690e8d536efb038cefe504d3807">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c13e9f21dd7c3b3cb7d3ec31ed802ac6">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff5fafbd67ab36d684a4b9be70163540">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c7b20088c80356287f0c94935a14fb7">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b77ea5c64881357a973bd9635d31280b">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="726985a112ad32829e8352db479d0ed9">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed3e07ec6caa3860bf7176e700d94808">
                      <SHORT-NAME>ICBAD_100ms_Group37_Reserved8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="4b45ba2d0a9934d6b85b43bdbca430be">
                      <SHORT-NAME>ICBAD_100ms_PDU25_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="306ff040a9ee3ad5a777cc0d798c0754">
                      <SHORT-NAME>ICBAD_100ms_PDU27_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="2ed3272652133e178bc5634b8ee13f80">
                      <SHORT-NAME>ICBAD_100ms_PDU29_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cdd531d35f543047bbccced79c6b4bac">
                      <SHORT-NAME>ICBAD_100ms_PDU31_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="91304dda144f3a9daceb7aefb474a257">
                      <SHORT-NAME>ICBAD_100ms_PDU34_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="80b6be7d09053c8fbe10f6f5195140f4">
                      <SHORT-NAME>ICBAD_100ms_PDU36_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c386aaec9c0e312fa723b336e22a4ca3">
                      <SHORT-NAME>ICBAD_100ms_PDU37_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="badff9d75f3d3429a16f825bf27d7000">
                      <SHORT-NAME>ICBAD_100ms_PDU38_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8c9f12b5434b3bb895538d4cb7d0d749">
                      <SHORT-NAME>ICBAD_100ms_PDU39_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="96b333e31aeb3b358b6d84e7ccec4679">
                      <SHORT-NAME>ICBAD_100ms_PDU44_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="30f93c1959ea33419a85210bf8583843">
                      <SHORT-NAME>ICBAD_20ms_Group05_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="70c6fefb833a38e0995759de8fd5394d">
                      <SHORT-NAME>ICBAD_20ms_Group05_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99e66fd6e4df3c589ba256d8deccc9d1">
                      <SHORT-NAME>ICBAD_20ms_Group05_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3387a83bc68c3f3299e68b973d042c2a">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved10_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="707d41cc483f3797b3cd79a1af02dc34">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved11_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff5e3f01b8593136be264a9378059661">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved12_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8ed8ad9ecc4f3cc694c0561a5ee39682">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved13_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3bcb85da6db3320780e7bb3aa57c2edf">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved14_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d83d1863c6a33b8890e015f052117702">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved15_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4eadc559ad334e4abb2291c1f8c3f57">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="38ed51c6097237baaea7476bdbff1242">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b82d70c0dac3286973bed6a3c02cdb4">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a71879e8469335c7a5dd6710a89ef544">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02d65e7d22543daf9b68a4dcc792ab04">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a785ffe4faa1391a9d27dc03018d75bc">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53f39a78949d32e2a276d29727b7dac4">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved7_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="33017b6aba7e3413a9ce5c035ffdb869">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved8_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fdee4c98e38431afbe860ce862bbc471">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved9_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6df8f0e191fe32febe666bff4c92d134">
                      <SHORT-NAME>ICBAD_20ms_Group07_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c80b2bf38c0317e855d63337f75e24c">
                      <SHORT-NAME>ICBAD_20ms_Group07_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1284847c94e231a1bf7e9e0f019791a4">
                      <SHORT-NAME>ICBAD_20ms_Group07_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0bd772615ec236ac95dba82fc3483b14">
                      <SHORT-NAME>ICBAD_20ms_Group07_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="626057622bfd33848bca283694c614ec">
                      <SHORT-NAME>ICBAD_20ms_Group09_CRC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13bd48a13fae3089bcdc5857b386614c">
                      <SHORT-NAME>ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2110a058f386323eb911ca44821d8d85">
                      <SHORT-NAME>ICBAD_20ms_Group09_RC_ICBAD_20ms_Group09_ICBAD_20ms_Group09_ICBAD_20ms_Group09_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b321b438bc7a373f902229a188338a4f">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb272dc38fd73bf799fc1cac79008022">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea6da508a8c33bfca64f1e57f19ca9c3">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf7cde6b56853846a08241c60b3e8e61">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab1cc6fd08c63bdda086fadbdf8d088a">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b9db10aa7953a9ab2c66960c7583c81">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02ca08faa8be3b2a87ec445b2fadea3b">
                      <SHORT-NAME>ICBAD_20ms_Group12_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27d55b05b2ad34cfa464b5d0f87c2529">
                      <SHORT-NAME>ICBAD_20ms_Group12_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="981c331e082c3b63928672f5703f087b">
                      <SHORT-NAME>ICBAD_20ms_Group12_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f448862482b033e387a78c6bd6587906">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9033c2a6a0fa370fbdedc22a982a74be">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="228dd9b561f63fc785a2b47bc716a6f8">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87e1999c8def3ef8b433abf864f26eed">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d61a2349e7bb3feb96ce988d281369f4">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc36e176caaf38fca7cc7725d481a5e5">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c1389b9f908336acad0e657f63bd6947">
                      <SHORT-NAME>ICBAD_20ms_Group13_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59502db167da3a6c91bbd9f02eed4401">
                      <SHORT-NAME>ICBAD_20ms_Group13_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6b1e896317db3b7b9774bb648bfd719a">
                      <SHORT-NAME>ICBAD_20ms_Group13_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2306264b009b3a32aaac2b9bba7da097">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="409af1ce326d3ccb9f51e267d2a191e9">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="757136a03aa9309ca77d0cec715bbd8e">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fdacfb390f737ecaa42c161ff0d54f1">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f338cb2e66063b5ca8385eb0e0e2ab0a">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="433886eaf92b3a3d9d8ac8f6020ed3c7">
                      <SHORT-NAME>ICBAD_20ms_Group46_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc6b83c7873835e1a5c16e0462279527">
                      <SHORT-NAME>ICBAD_20ms_Group46_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="040ed2515eb53d77b73aad4df025d76f">
                      <SHORT-NAME>ICBAD_20ms_Group46_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77ea4e46e85f316a9c461eea9d16c5a8">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c97c9abee074393a92aa00553de4e3a4">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3fce3bf36b233f58e253c27ab5b81de">
                      <SHORT-NAME>ICBAD_20ms_Group48_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a37937adea3c3cbd936e5bbfa7fe652a">
                      <SHORT-NAME>ICBAD_20ms_Group48_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c904a24c65b43a7fb3cadac1f755db77">
                      <SHORT-NAME>ICBAD_20ms_Group48_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0ba6617c7bfa3f4cbf0ef731d5cf379d">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1fea9a2ae32132f28e3ec8c800e30907">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f681b67a257363988322e302286ad9d">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8fb5c7afbbc638d0be826dbffc76d29e">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d27227dc8e903550adeea21a2b676704">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bfe0a467b9413daa985b23db4f1dd124">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="b82479355b0a35cf821385d5663c4947">
                      <SHORT-NAME>ICBAD_20ms_PDU05_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="afe3a3a564953ad1aca7a0a18d76abd3">
                      <SHORT-NAME>ICBAD_20ms_PDU07_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="6288164a1e3131ab9fdb0bc24d27b03c">
                      <SHORT-NAME>ICBAD_20ms_PDU08_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="81d3bab7475b3647839c5aefada017fe">
                      <SHORT-NAME>ICBAD_20ms_PDU09_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cdd9a359ac5d3b62ac5324bf067a2d40">
                      <SHORT-NAME>ICBAD_20ms_PDU12_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5f30d968560b324695824f1d49d07455">
                      <SHORT-NAME>ICBAD_20ms_PDU13_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ee24a62b0a063644a069c334663b4df5">
                      <SHORT-NAME>ICBAD_20ms_PDU46_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="99f7cc0fc4d3376bbbd0beecbad1c2c9">
                      <SHORT-NAME>ICBAD_20ms_PDU48_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="48577c5d49433cdd8f3c2904cc6c74cd">
                      <SHORT-NAME>ICBAD_50ms_PDU17_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="582844528c1c35ed81dfcacbfe4102f1">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP27_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="66340cd9344a352ebc38b7f882464a09">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP29_NoSecOC_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6638444bbe293d0dbd66a4392c6690d9">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP34_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="095ac72039ca3be18e083fa428d66bc9">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP36_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2b119644e5f8328dba5f2291196126f6">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP37_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c4a266a2e38c3b688075383da592b8e8">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP38_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4f4ee521d5cc33c4989bf7103e1fad9c">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP39_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f47c977418b632bba14ca1eacabb135b">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP44_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b07cd298878c322da4dbf68a0d0b3a5b">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1580be8d0a8c3554aa53fb5f2b9320ab">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP09_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="722e63019f9231d5b408795886ff376f">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="09400f6f1fca39639dc6e4fad39e31d1">
                      <SHORT-NAME>ICBAD_BKPCANFD_50ms_FrP17_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="17a6bf1d450636b9af78f330eb2a0152">
                      <SHORT-NAME>ICBAD_CHCANFD_100ms_FrP25_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1e20463ba6763d60b957aa5a7c7565b1">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="15928d3189403be1bdac346ef32949af">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c01fe592fba8307fb07a6a12422c6e42">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP48_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0eae5a6f06403eefacef96495d6aa6e3">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1de2309a8aa63300a25f32b5aef4a00c">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="b75140d25c933f8dba4adc86c6531ea7">
                      <SHORT-NAME>ICBAD_SecOCComKeyResp_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="a1feafb5324230d594fa101b54ddd142">
                      <SHORT-NAME>ICBAD_SecOCLog_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="5ccda58963273581932c76312ffcd70e">
                      <SHORT-NAME>ICBAD_SecOC_ComKeyResp_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f581db651c283497aec2310da27233ff">
                      <SHORT-NAME>ICBAD_SecOC_Log_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="d2f6a690217d3014842bdf65f27e5463">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6820f0e3efa630c4916facafe7d60183">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="35413913706a3d8d81397e09f9bca3c2">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2f741c16bfdb36b2bec51950392e88bf">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f1c1ae07d263ce7b7d60e4e3db020da">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a61f75272f9135479e6e1b90bf92015b">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2d6fe5da73e3098b27141d3aebd57e2">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f14512fca23939d59e56f4db68368861">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b15e28e763cc32d3bcf8da1f508752dc">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6_IPD_BKPCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="300a08fa2fc03c06b3257ab13b4310c9">
                      <SHORT-NAME>ICBAD_ZONE_20ms_PDU13_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="b63e477115dd316487a50197c11b78c9">
                      <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="35bb36b6052537e4bb68f67dd9f304b2">
                      <SHORT-NAME>ICBVC_1000ms_PDU50_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="ae37e40795a139dc98d27be697e83075">
                      <SHORT-NAME>ICBVC_100ms_Group01_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e33ae21758d43a55bfde72483038bf82">
                      <SHORT-NAME>ICBVC_100ms_Group01_ICBVC_100ms_Group01_ICBVC_100ms_Group01_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0dd65cddca8031fa8252906a8ff96ac6">
                      <SHORT-NAME>ICBVC_100ms_Group01_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c7a9c469a79e3f3a8525e68137051c51">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved103_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de0914d10c673ba39818d89fab795254">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved111_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26180691492b3e5c9437069c76186950">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved119_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7501f71a393234bf8a45f08ba5fa27b8">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved127_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb2387ab91f732118f0e131f5e7821a0">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved14_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e69a725c11a32d5acd68347ce2b6c89">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved21_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b46bb653a373270852641d842287933">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved31_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="62deff7117323779acfe17d6d0a67cf2">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved47_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b8cc7cc5d07363b98d2f56ba7bead2a">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved55_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ac30c812ac93092b075a59cd300b395">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved63_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3436114d3cc3009beedb5ba1814c5d2">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved71_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="858bc2124cb43418b2b53e23cff5eac4">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved72_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d8877e5e4853641b153768633259b12">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved79_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="36400f88bf453a0a84597643b26ad608">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved80_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99cc9193d7cd3072ac2696f08ed94e37">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved84_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6db1bda3a67836e9a3c363d804bdeb9c">
                      <SHORT-NAME>ICBVC_100ms_Group01_Reserved92_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8df80a31ee043605bcb8da4afdc045e0">
                      <SHORT-NAME>ICBVC_100ms_Group80_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d06fa0f6899a370580910030a8d82147">
                      <SHORT-NAME>ICBVC_100ms_Group80_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="269089b6a3f93563b59476e57d192ec5">
                      <SHORT-NAME>ICBVC_100ms_Group80_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27182fb0aed134a9a298414c31601680">
                      <SHORT-NAME>ICBVC_100ms_Group80_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c4bd5d010af33879727ff3f6870270b">
                      <SHORT-NAME>ICBVC_100ms_Group80_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c8dc13c81b13e9eab1a53af4b89cc6f">
                      <SHORT-NAME>ICBVC_100ms_Group80_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="d791a47774e23719b4565ffbdd527786">
                      <SHORT-NAME>ICBVC_100ms_PDU01_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="9450fa48631e3d1ea8fecf581f3a1faa">
                      <SHORT-NAME>ICBVC_100ms_PDU17_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="803e41acd20a31e288ffef8e0c3b44b9">
                      <SHORT-NAME>ICBVC_100ms_PDU257_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="640d79b2bac93ae5b2ab980f3733235d">
                      <SHORT-NAME>ICBVC_100ms_PDU25_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5f6f665ce9cf34258cfacc4a81d36c7f">
                      <SHORT-NAME>ICBVC_100ms_PDU27_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e3c1fc409ec0388197f50739630f2a9c">
                      <SHORT-NAME>ICBVC_100ms_PDU31_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="2efb3bcb1360303cbc399a3b31de77e1">
                      <SHORT-NAME>ICBVC_100ms_PDU35_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f9a005ea29e7344db5233a2ef864bc52">
                      <SHORT-NAME>ICBVC_100ms_PDU47_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ccfafe644aa63eacbfe77d284e4648c3">
                      <SHORT-NAME>ICBVC_100ms_PDU48_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="58475d6f98623b778b5e72e18fa3870a">
                      <SHORT-NAME>ICBVC_100ms_PDU80_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="b368db6b344d3f408db0d0cd09cbec08">
                      <SHORT-NAME>ICBVC_200ms_Group79_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c226f7a980da3ece88567013df802f6e">
                      <SHORT-NAME>ICBVC_200ms_Group79_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f452b4c40a603d06b05c88a9ca4794a5">
                      <SHORT-NAME>ICBVC_200ms_Group79_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2834708c73b237518d2590c1aec148d7">
                      <SHORT-NAME>ICBVC_200ms_Group79_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e91426c710cf307b81d5e0b1a26a5188">
                      <SHORT-NAME>ICBVC_200ms_Group79_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="01e3bb9375043b6da6ba67cb5f0fd21a">
                      <SHORT-NAME>ICBVC_200ms_PDU50_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d9116a31be2d3cd98287696dda66bb96">
                      <SHORT-NAME>ICBVC_200ms_PDU79_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="82d00ba496823058a3c3a4012e0d23f3">
                      <SHORT-NAME>ICBVC_20ms_Group03_CRC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3b8e89a591b33ddea7f06236d14c7f1c">
                      <SHORT-NAME>ICBVC_20ms_Group03_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c6623cfd63e31e28dd9c7e48ef00149">
                      <SHORT-NAME>ICBVC_20ms_Group03_RC_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="44ef87f13f0d3bbabe9b2a10fa346e5a">
                      <SHORT-NAME>ICBVC_20ms_Group03_Reserved1_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f9dd0fa1e933dab9dbfb33759b71cc3">
                      <SHORT-NAME>ICBVC_20ms_Group03_Reserved2_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7cbcfd8b52ca3baba2ab5160e9048cd2">
                      <SHORT-NAME>ICBVC_20ms_Group03_Reserved3_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8744899323f34f48b3342d5e47e2f44">
                      <SHORT-NAME>ICBVC_20ms_Group03_Reserved4_IPD_BKPCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="89eab3def0723203b9953b9ba04c8b8c">
                      <SHORT-NAME>ICBVC_20ms_PDU00_IPD_BKPCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="bb3831b830ea3ae8aa4860c7c7112aee">
                      <SHORT-NAME>ICBVC_20ms_PDU03_IPD_BKPCANFD</SHORT-NAME>
