            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e1bc9XOa505a3f19f25843c4b2e1bc800">
              <SHORT-NAME>IEPS_20ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPAInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAPASts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPS_20ms_Group03_Reserved5</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/EPS_20ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2dfe80XOa505a3f19f25843c4b2dfe7f00">
              <SHORT-NAME>IESS_100ms_Group25</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSNegPtIsltnRstc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSNegPtIsltnRstcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSPosPtIsltnRstc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSPosPtIsltnRstcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group25_Reserved4</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ESS_100ms_Group25</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36780cXOa505a3f19f25843c4b36780b00">
              <SHORT-NAME>IESS_100ms_Group58</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOfbdChrgrSktVolV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBMSOffBdChrgrPlugOnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_100ms_Group58_Reserved7</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ESS_100ms_Group58</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36c909XOa505a3f19f25843c4b36c90800">
              <SHORT-NAME>IFDR_100ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDR_100ms_Group01_Reserved7</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FDR_100ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369f16XOa505a3f19f25843c4b369f1500">
              <SHORT-NAME>IFVCM_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_10ms_Group01_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqAngSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAReqToqSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FVCM_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2ee650XOa505a3f19f25843c4b2ee64f00">
              <SHORT-NAME>IFVCM_20ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDetObjDistLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDrvrSelTrgtSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoNotfr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCMsgReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSeldTrgtDistLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTotWhlToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSysSts_IPD</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOffRoadDetnStaV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCM_20ms_Group02_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHandOffStrgWhlDetnStaV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnDircnDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCActvnVelDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAAudReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKADspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKADrvrTkovReq</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/FVCM_20ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbbdddXNa505a3f19f34f4acdbbbdd700">
              <SHORT-NAME>IIAM_100ms_Group08</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAltSigma</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group08_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILatSigma</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILonSigma</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group08</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbbbb9XNa505a3f19f34f4acdbbbbb300">
              <SHORT-NAME>IIAM_100ms_Group18</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHeadingSigma</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group18_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPitchRTK</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPitchSigma</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group18</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbba1cXNa505a3f19f34f4acdbbba1600">
              <SHORT-NAME>IIAM_100ms_Group56</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_100ms_Group56_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_GNSS_Signal_Status</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILatitudeRTK</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_100ms_Group56</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b375866XOa505a3f19f25843c4b37586500">
              <SHORT-NAME>IIAM_20ms_Group32</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_20ms_Group32_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtDrvrTrgtEPSStrgWhlAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtParkngAstAbotBtnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtParkngAstBtnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtParkngAstDvcFlrRsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtParkngAstDvcSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRmtParkngAstParkngOutDircnSeln</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehBkwdSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehBkwdSwReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehFwdSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehFwdSwReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehRoadWhlLReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehRoadWhlLReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehRoadWhlRReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehRoadWhlRReqV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_20ms_Group32</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbb437XNa505a3f19f34f4acdbbb43100">
              <SHORT-NAME>IIAM_ZONE_100ms_Group13</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFixType</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSSeq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSUTCTimeH</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group13_Reserved13</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group13</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbb65bXNa505a3f19f34f4acdbbb65500">
              <SHORT-NAME>IIAM_ZONE_100ms_Group34</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHdop</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group34_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPdop</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVdop</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group34</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbb87fXNa505a3f19f34f4acdbbb87900">
              <SHORT-NAME>IIAM_ZONE_100ms_Group35</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSF9HCounter</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGNSSUTCTime</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group35_Reserved15</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group35</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbc121XNa505a3f19f34f4acdbbc11b00">
              <SHORT-NAME>IIAM_ZONE_100ms_Group40</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAltitudeRTK</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHeadingRTK</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group40_Reserved63</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group40</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbc00bXNa505a3f19f34f4acdbbc00500">
              <SHORT-NAME>IIAM_ZONE_100ms_Group57</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAM_ZONE_100ms_Group57_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILongitudeRTK</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IAM_ZONE_100ms_Group57</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e25b9XOa505a3f19f25843c4b2e25b800">
              <SHORT-NAME>IIBS_100ms_Group15</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFltAlrm_GB</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFrc_GB</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICsbLvlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnRstOcd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnSrc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistRCAvgDrvnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSABSlvlResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSESPlvlResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSTCSlvlResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_100ms_Group15_Reserved6</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_100ms_Group15</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3659f8XOa505a3f19f25843c4b3659f700">
              <SHORT-NAME>IIBS_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistPlsCtr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistTmsp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDistV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlRstOcd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlSeqNum</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDistPlsCtr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDistTmsp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDistV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlRstOcd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlSeqNum</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b365b84XOa505a3f19f25843c4b365b8300">
              <SHORT-NAME>IIBS_10ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistPC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistT</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDistV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlRstOcd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlSeqNum</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDistPC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDistT</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDistTRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDistV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlRstOcd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlSeqNum</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e2580XOa505a3f19f25843c4b2e257f00">
              <SHORT-NAME>IIBS_10ms_Group04</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlPosV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysBrkLghtsReqd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysEnToqReqProtn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysBrkLghtsReqdA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_10ms_Group04_Reserved6</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_10ms_Group04</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e258dXOa505a3f19f25843c4b2e258c00">
              <SHORT-NAME>IIBS_20ms_Group07</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IABSIO</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVHSigPdlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldMdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldMsg</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoHoldSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysHillStAstAvlbl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysHillStAstSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysRedBrkTlltReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysYlwBrkTlltReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBDA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBDFaultSt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkAV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDragToqRducnA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHBAActiveSt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHBAValidSt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHDCSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group07_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group07_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMSRA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMSRF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMulColBrkA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMulColBrkAvlblySts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMultColBrkEnbA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgtvBrkFnFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgtvBrkFnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISoftSpSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCSA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCSEnbd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCSOpngMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCSOpngSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSEMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSESts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSESysA</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group07</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e2598XOa505a3f19f25843c4b2e259700">
              <SHORT-NAME>IIBS_20ms_Group08</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysSecyBrkAxleToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysSecyBrkAxleToqValV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTrBrkAxleToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTrBrkAxleToqValV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAPAAvlbl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAppcnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAvlblySts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBCCCanclReqd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSwSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSwStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysAudWrnngReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysDspMsgReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysStsIndReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBSysWrnngIndReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group08_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group08_RC</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group08</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3662ffXOa505a3f19f25843c4b3662fe00">
              <SHORT-NAME>IIBS_20ms_Group09</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTotBrkAxleToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChSysTotBrkAxleToqValV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group09_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDircn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDircn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelLDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelLDrvnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelRDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelRDrvnV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group09</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e25a3XOa505a3f19f25843c4b2e25a200">
              <SHORT-NAME>IIBS_20ms_Group10</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkDiscTemSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFludLvlLow</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkFludLvlLowV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlAppd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlAppdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrs</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsDet</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsDetV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlDrvrAppdPrsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlMdlActSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlMdlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlSimltdPrs</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkPdlSimltdPrsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqOtptRodTrvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqOtptRodTrvlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group10_Reserved2</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group10</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36648aXOa505a3f19f25843c4b36648900">
              <SHORT-NAME>IIBS_20ms_Group11</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group11_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvg</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgDrvnSrc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgDrvnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgNonDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgNonDrvnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSpdAvgV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group11</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3665acXOa505a3f19f25843c4b3665ab00">
              <SHORT-NAME>IIBS_20ms_Group12</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group12_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDircn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILNonDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDircn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRNonDrvnWhlRotlDircnSdslSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelLNonDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelLNonDrvnV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelRNonDrvn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlGndVelRNonDrvnV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group12</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e25aeXOa505a3f19f25843c4b2e25ad00">
              <SHORT-NAME>IIBS_20ms_Group13</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCBrkngA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqRespV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSysRddySysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChACCAccReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChACCReqFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBBrkJerkReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBDclReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBHydBrkAstReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChAEBPrflReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChEBADclReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChRCTBDclReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChRCTBPrflReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmgcBrkReqdByIECUSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtnlBrkPrio</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtnlBrkPrioV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSAPASysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group13_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_20ms_Group13_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMultColBrkAvlblySts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSAPAAcclA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSAPAAcclAV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSAutodDrvngSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSAutodDrvngSysStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSVehHoldA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCSVehHoldAV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCSDrvrItnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSdslSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSdslStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWhlBrkPrsSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_20ms_Group13</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b366edaXOa505a3f19f25843c4b366ed900">
              <SHORT-NAME>IIBS_ZONE_20ms_Group08</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkBstFnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPBAppcnSts_M</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBSRespAccToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_ZONE_20ms_Group08_Reserved5</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IBS_ZONE_20ms_Group08</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37e6c8XOa505a3f19f25843c4b37e6c700">
              <SHORT-NAME>IICBAD_100ms_Group25</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved135</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved143</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved151</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved159</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved167</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved175</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved183</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved191</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved87</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group25_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSlntPtrlEnbSwResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSwResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEBSysFltSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_100ms_Group25</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b2edXOa505a3f19f25843c4b34b2ec00">
              <SHORT-NAME>IICBAD_100ms_Group37</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngMsgReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSetResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSwDspCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDILampsCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHzrdLampsCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_100ms_Group37_Reserved8</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_100ms_Group37</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36a2b1XOa505a3f19f25843c4b36a2b000">
              <SHORT-NAME>IICBAD_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSToqAppdCoefnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved16</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved17</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved18</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved19</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved20</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved21</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved22</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_10ms_Group01_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPltEPSRdWhlAngReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPltEPSRdWhlAngReqStsV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369039XOa505a3f19f25843c4b36903800">
              <SHORT-NAME>IICBAD_20ms_Group05</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACrpSpdReqVal_IPD</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPARevrDrgReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATotWhlToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVCUReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group05_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group05</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369fdbXOa505a3f19f25843c4b369fda00">
              <SHORT-NAME>IICBAD_20ms_Group07</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqSts_CH</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCGoReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSdslReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPkgAPASCSAcclReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEPBOPReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSAcclReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysEmgcBrkReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysFlrStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysMdReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSDrvOffReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSCSSdslReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group07_Reserved1</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group07</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b240XOa505a3f19f25843c4b34b23f00">
              <SHORT-NAME>IICBAD_20ms_Group09</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group09_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSABacSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSADisFucSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSAForSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INSAReqAVMDis</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group09</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369220XOa505a3f19f25843c4b36921f00">
              <SHORT-NAME>IICBAD_20ms_Group12</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group12_Reserved6</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group12</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3692a7XOa505a3f19f25843c4b3692a600">
              <SHORT-NAME>IICBAD_20ms_Group13</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPACmdEPSSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCUReqStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAShifterPosReqdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPATrgtEPSStrgWhlAng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group13_Reserved5</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group13</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b31adb3XOa505a3f19f25843c4b31adb200">
              <SHORT-NAME>IICBAD_20ms_Group15</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCDclReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCOtptShaftTotToqReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCOtptShaftTotToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngSysStsPT</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group15_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group15</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36a357XOa505a3f19f25843c4b36a35600">
              <SHORT-NAME>IICBAD_20ms_Group46</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBBrkJerkLvlReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBHydBrkAstLvlReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBPrflReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group46_Reserved2</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group46</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36a479XOa505a3f19f25843c4b36a47800">
              <SHORT-NAME>IICBAD_20ms_Group48</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_20ms_Group48_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKALVsulznReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKARVsulznReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAVbnLvlReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSysSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_20ms_Group48</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36a165XOa505a3f19f25843c4b36a16400">
              <SHORT-NAME>IICBAD_ZONE_10ms_Group20</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_10ms_Group20_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAToqReqValMax</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKAToqReqValMin</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_ZONE_10ms_Group20</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36a1ecXOa505a3f19f25843c4b36a1eb00">
              <SHORT-NAME>IICBAD_ZONE_20ms_Group13</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBAD_ZONE_20ms_Group13_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILKASysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITJAICASysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITJAICASysSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBAD_ZONE_20ms_Group13</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbd4c7XNa505a3f19f34f4acdbbd4c100">
              <SHORT-NAME>IICBVC_100ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdVehSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDspMeasmtSys</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHeatCtrlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVentCtrlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatHeatCtrlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatVentCtrlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved21</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved72</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved80</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved84</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group01_Reserved92</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMdOfPwrMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDCSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdExtrCtrlAvlbl</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f34f4acdbbe783XNa505a3f19f34f4acdbbe77d00">
              <SHORT-NAME>IICBVC_100ms_Group19</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAuxBatUnAssembled</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMCurEstdCapct</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMMaxEstdCapct</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPMOprtMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTToqCustSetngReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTToqCustSetngReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReqRaw</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnrgSplReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved21</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved35</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group19_Reserved58</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBMDisChrgMOSCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatChrgReqInhbt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatChrgReqRaw</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatEnrgLow</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatEnrgSufct</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBatSelfWakeupFlg</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPMDCSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgnLvReqFICM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRgnLvReqFICMV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehEnrgRdyLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehEnrgRdyLvlV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group19</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369d27XOa505a3f19f25843c4b369d2600">
              <SHORT-NAME>IICBVC_100ms_Group80</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReqV_Sfty</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReq_Sfty</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDrvngMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehLdShedLvl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehOdo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehOdoV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_100ms_Group80</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b369de9XOa505a3f19f25843c4b369de800">
              <SHORT-NAME>IICBVC_200ms_Group79</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdAirbagWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTNotReadyReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcs</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrlrMdSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_200ms_Group79</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3693c9XOa505a3f19f25843c4b3693c800">
              <SHORT-NAME>IICBVC_20ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAMRPrtensonReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBPMMstrAvlbly</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdMstrAccryA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdMstrRunCrkA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysOpnlMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVol</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolMdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IUsgMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IUsgMdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehMdV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_20ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e908fXOa505a3f19f25843c4b2e908e00">
              <SHORT-NAME>IICBVC_50ms_Group11</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCanclSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistDecSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistIncSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsOnSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsRsmSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdDecSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdIncSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSwDataIntgty</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHMISafFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnEnbSwSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnSecySwSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnSwSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSCnfmSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelDwnSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelLSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelRSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelUpSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlTipcSwDataIntgty</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISwStaE2EErr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw1A</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw2A</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw3A</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw4A</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group11</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34bd49XOa505a3f19f25843c4b34bd4800">
              <SHORT-NAME>IICBVC_50ms_Group13</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocParkngSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrSsdManuCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved16</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMATESysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdCtrlResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtMdFICM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITgtParkingChosed</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group13</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e8fb3XOa505a3f19f25843c4b2e8fb200">
              <SHORT-NAME>IICBVC_50ms_Group158</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisAdjtVcCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisDecAndIncVcCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdDecAndIncVcCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmdSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCCASwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSetSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group158</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e96a3XOa505a3f19f25843c4b2e96a200">
              <SHORT-NAME>IICBVC_50ms_Group256</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved100</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved85</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved96</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvtDist</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlope</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlopeDist</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetection</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetectionDist</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSCnfmSwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSLFnChngSwA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB1SwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB2SwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB3SwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelLSwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelRSwStuckL</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehboardSetting</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/ICBVC_50ms_Group256</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b379d21XOa505a3f19f25843c4b379d2000">
              <SHORT-NAME>IIMM_50ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormBehvor_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrAbnormConf_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnConf_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnStsINST_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstcnSts_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgConf_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvlINST_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvl_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrGazeRgn_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrPrst_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazepitch_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeGazeyaw_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOnRoad_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenDegree_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEyeOpenStatus_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILBRReq_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved143</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved151</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved159</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMM_50ms_Group02_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILeftEyeOccludeStatus_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMouthOccludeStatus_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOMSSts_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRightEyeOccludeStatus_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpfngDet_IMM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IYawnStatus_IMM</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IMM_50ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b556XOa505a3f19f25843c4b34b55500">
              <SHORT-NAME>IIPD_20ms_Group43</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCAccReqToqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSysFltSts_SCS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group43_Reserved5</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group43</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b37fXOa505a3f19f25843c4b34b37e00">
              <SHORT-NAME>IIPD_20ms_Group60</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IALCSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatAzmth</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosX</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAVehCrdnatPosY</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngLLaneSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngRLaneSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDirInd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSDrvrTkovReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSSysSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group60_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSysSts_ZPD</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngslottype</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPilotTkovMsgReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPrkgDstCtrlSwResp</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group60</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b376cfcXOa505a3f19f25843c4b376cfb00">
              <SHORT-NAME>IIPD_20ms_Group64</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSBrkFnMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSDrvrReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngPrflReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngTrgtDist</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSParkngVelMax</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASCSReqSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group64_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group64</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37f849XOa505a3f19f25843c4b37f84800">
              <SHORT-NAME>IIPD_20ms_Group67</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADS_SpdAstSysTrgtSpdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_20ms_Group67_Reserved95</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_20ms_Group67</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b375a19XOa505a3f19f25843c4b375a1800">
              <SHORT-NAME>IIPD_50ms_Group14</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group14_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSInfoDispReqToICM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSProgressBar</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWLSFObsRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWLSRObsRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWRSFObsRng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDWRSRObsRng</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_50ms_Group14</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36edd6XOa505a3f19f25843c4b36edd500">
              <SHORT-NAME>IIPD_50ms_Group49</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAEnRunReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_50ms_Group49_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeepPwrRsnIPD</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILADSAFnInd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMdCtrl</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_50ms_Group49</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3719b5XOa505a3f19f25843c4b3719b400">
              <SHORT-NAME>IIPD_Sporadic_TimeSync_Group</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgCheckSum</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgOVS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgSGW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgSequenceCounter</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgTime</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgTimeDomain</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgType</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISyncMsgreserved</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/IPD_Sporadic_TimeSync_Group</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b6f6XOa505a3f19f25843c4b34b6f500">
              <SHORT-NAME>ILHZCU_100ms_Group30</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnIndLampSwStsMntry</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatHorzPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSeatVertPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved87</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_100ms_Group30_Reserved95</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_100ms_Group30</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37fdc4XOa505a3f19f25843c4b37fdc300">
              <SHORT-NAME>ILHZCU_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyAuthReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDigKeyPEValidReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqParkBtn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IKeyAuthResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUAPAUnderCtrlActv</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvMd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvrIntrvnActv</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUExtdShiftrFlr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUFltLvlWarn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqEPMCU</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkLckReqVEPMCU</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrPosn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrPosnLtchActv</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrLvrRawPosn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrOpngRmndr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShiftrPosnInvsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecuKeyVldSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b376dd6XOa505a3f19f25843c4b376dd500">
              <SHORT-NAME>ILHZCU_10ms_Group32</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtOnReq_LHZCU</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqGearShftPosInvs</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEleccTrRngReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDayTimeRunningLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUWKSTS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_10ms_Group32_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMainBeamLghtSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDayTimeRunningLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLightOnReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUActrMvmntSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvnIntrvnPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUExtdShifterActrPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUParkActrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShftLvrPosIncnstntFlag</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUShftLvrPosTrgt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUTapUpDwnSwSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUTapUpDwnSwStaInvsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISideLghtOnReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKey4LoctnResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKeyLoctnFlrRsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISmrtKeyLoctnProc</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_10ms_Group32</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e36abXOa505a3f19f25843c4b2e36aa00">
              <SHORT-NAME>ILHZCU_20ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDippedBeamActStatus</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHzrdLghtSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_20ms_Group03_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILMainBeamLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPriySSBA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPriySSBAV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRMainBeamLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISSBTrigd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecySSBA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISecySSBAV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_20ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34bc07XOa505a3f19f25843c4b34bc0600">
              <SHORT-NAME>ILHZCU_400ms_Group18</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_400ms_Group18_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSTirePrsLowIO</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_400ms_Group18</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e36b6XOa505a3f19f25843c4b2e36b500">
              <SHORT-NAME>ILHZCU_50ms_Group06</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBntOpenSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDirnLghtSftyMonErr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDetSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDoorOpenSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group06_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDoorOpenSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSInitnFltPrst</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehLckSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_50ms_Group06</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37a1b9XOa505a3f19f25843c4b37a1b800">
              <SHORT-NAME>ILHZCU_50ms_Group24</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtMdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDircnLghtSwReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHUDLkngAmbtLghtLvlByLux</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved121</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved135</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved143</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved151</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved159</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved49</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved60</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved81</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved87</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCU_50ms_Group24_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSideLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRSideLghtCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehHzrdMdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehIlluminateCtrlCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSideLghtSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/LHZCU_50ms_Group24</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368badXOa505a3f19f25843c4b368bac00">
              <SHORT-NAME>IPEU_10ms_Group25</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotADampTrqCmdd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAMdAch</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotASpdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAch</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotAToqAchV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBDampTrqCmdd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBMdAch</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBSpdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAch</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEUMotBToqAchV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved147</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_10ms_Group25_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlDrvTqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IReAxleMaxAvlblWhlRgtnTqV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PEU_10ms_Group25</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b367f49XOa505a3f19f25843c4b367f4800">
              <SHORT-NAME>IPICU_10ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqFrtAxleWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrReqRrAxleWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtAxleActuWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group03_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtHVCntarReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrAxleActuWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITotActuWhlToqV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_10ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e4984XOa505a3f19f25843c4b2e498300">
              <SHORT-NAME>IPICU_10ms_Group23</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICrkshftNonTrRegdCmddToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnComFlrRducdPwrCmdd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffAld</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDclFuelCutOffSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelCutA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnFuelRcvrySpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnHybVehStaOvrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnIdleCtrlSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnReqdStTyp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnStCtrlA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSynRdy</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSysDsbld</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnSpdReqF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybEnStSpOvrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_10ms_Group23_Reserved18</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtACCA</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSEnRunning</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_10ms_Group23</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b375fb1XOa505a3f19f25843c4b375fb000">
              <SHORT-NAME>IPICU_20ms_Group11</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICstRgtnBrkLgtReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICstRgtnBrkLgtReqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHybAPAAvlbl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMaxAvlblTotWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMinAvlblTotWhlToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_20ms_Group11_Reserved9</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqImmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqPrdtd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRdundtHybCmddEnToqRespTyp</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/PICU_20ms_Group11</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b7acXOa505a3f19f25843c4b34b7ab00">
              <SHORT-NAME>IRFSDA_20ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqSts_ADAS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqToqVal_ADAS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBDclReqVal_ADAS</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRFSDA_20ms_Group02_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RFSDA_20ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2ee916XOa505a3f19f25843c4b2ee91500">
              <SHORT-NAME>IRHRDA_50ms_Group04</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBSDSelSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDOWSelSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILBSDAndLCAWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCASelSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDOWWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILRCTAWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRBSDAndLCAWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRCTSysSelSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDASwSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDASysSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDOWWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDA_50ms_Group04_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLRdrEmgcLineChngWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRCTAWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRRdrEmgcLineChngWrnng</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrCrnRdrCalSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHRDA_50ms_Group04</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37fdefXOa505a3f19f25843c4b37fdee00">
              <SHORT-NAME>IRHZCU_100ms_Group10</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTemMsk</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACAmbtTemV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACComprActuPwr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatHorzPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSeatVertPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_100ms_Group10_Reserved4</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_100ms_Group10</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368df5XOa505a3f19f25843c4b368df400">
              <SHORT-NAME>IRHZCU_50ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group01_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw41DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw41Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDoorOpenSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_50ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e6728XOa505a3f19f25843c4b2e672700">
              <SHORT-NAME>IRHZCU_50ms_Group27</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCU_50ms_Group27_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw33DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw33Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw37DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw37Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw3DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw3Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw42DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw42Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw43DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw43Sts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw9DiagSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUeSw9Sts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RHZCU_50ms_Group27</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3685edXOa505a3f19f25843c4b3685ec00">
              <SHORT-NAME>IRZCU_100ms_Group10</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEleccLckCtrlResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFlbStrgFnSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFlbStrgFnStsResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMU_Signal_status</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOfbdChrgrNgtvSktTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOfbdChrgrNgtvSktTemV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktElecLckSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktElecLckStaV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktPstvSnsrTem</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSktPstvSnsrTemV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrSktEleccLckEnable</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_100ms_Group10_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUCtrlS2Req</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_100ms_Group10</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368636XOa505a3f19f25843c4b36863500">
              <SHORT-NAME>IRZCU_10ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoChrgngMngmnt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelActuPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelActuPosV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAccelEfctvPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTBrkPdlDscrtInptSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTBrkPdlDscrtInptStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTCrkAbotd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTHVDCDCMdReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTHVEmgcPwrOffReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTMainRelayDrvReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTStCmdOn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IElecMotEmgcShutDwn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSEPTRdy</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group01_Reserved3</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b36814fXOa505a3f19f25843c4b36814e00">
              <SHORT-NAME>IRZCU_10ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTSecyAxleInptShaftSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTSecyAxleInptShaftSpdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpdV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpdV_R</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrInptShaftSpd_R</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group02_Reserved1</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2eadf0XOa505a3f19f25843c4b2eadef00">
              <SHORT-NAME>IRZCU_10ms_Group22</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMaxAvlblToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMaxAvlblToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMinAvlblToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotMinAvlblToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotToq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTTrOtptShaftTotToqV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group22_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarReWhlTqMaxLmt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarReWhlTqMaxLmtV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarWhlTqMaxLmt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVMCTarWhlTqMaxLmtV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group22</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3684c0XOa505a3f19f25843c4b3684bf00">
              <SHORT-NAME>IRZCU_10ms_Group23</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPilotSysSaBrInh</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIPilotSysSaBrSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelOvrd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutodDrvngToqReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtACCToqReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtAPAToqReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved10</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved11</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved12</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved13</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved14</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved7</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved8</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group23_Reserved9</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group23</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368547XOa505a3f19f25843c4b36854600">
              <SHORT-NAME>IRZCU_10ms_Group24</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTAPARevrDrgReqResp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPtAPASts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group24_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUAPAFltRsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCUAPAUnderCtrlA</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group24</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37f658XOa505a3f19f25843c4b37f65700">
              <SHORT-NAME>IRZCU_10ms_Group90</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved135</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved143</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved151</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved159</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved83</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved87</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_10ms_Group90_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVCU_ISAOvSpdOvRd</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group90</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b368796XOa505a3f19f25843c4b36879500">
              <SHORT-NAME>IRZCU_20ms_Group06</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTRdy</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTRdyV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_20ms_Group06_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdSta</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdStaV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGear</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGearV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPosV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_20ms_Group06</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b34b808XOa505a3f19f25843c4b34b80700">
              <SHORT-NAME>IRZCU_50ms_Group37</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtFltSts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtSts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IChrgrFlapLtchCtrl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILdspcOpenStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrLftgtClsSwtActv</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtFltsts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLDircnLghtSts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtFltsts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRRDircnLghtSts_HW</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved23</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved34</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved36</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved38</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_50ms_Group37_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRearFogLghtFltsts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRearFogLghtSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtFltSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_50ms_Group37</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2eaf12XOa505a3f19f25843c4b2eaf1100">
              <SHORT-NAME>IRZCU_ZONE_10ms_Group64</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationXsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationXsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationYsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationYsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationZsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAccelerationZsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateXsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateXsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateYsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateYsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateZsecinfo</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAngularRateZsecinfoV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMUTmp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMUseq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved5</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_ZONE_10ms_Group64_Reserved6</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITireBlowoutPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITireBlowoutStabCtrlSts</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_ZONE_10ms_Group64</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e7239XOa505a3f19f25843c4b2e723800">
              <SHORT-NAME>ISDM_20ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplForeCall</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsneForeCall</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltForeCall</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnDrvrSbltIndCmdEvtTyp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtPsngSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSbltAudRmndr</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowLSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowMidSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnSecRowRSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowLSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowMidSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnThrdRowRSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group01_Reserved4</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b2e7246XOa505a3f19f25843c4b2e724500">
              <SHORT-NAME>ISDM_20ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDpl</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagDplInvsn</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFlt</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirbagSysFltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFMOccupntSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtc</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltAtcV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFasnFrtRowMidSbltIndCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagDsblIndF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagEnbIndF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagIndReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysDplStsV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPedtrnProtnSysIndrCmd</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved16</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved31</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved37</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved51</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved57</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group02_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehCrshTyp</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b367103XOa505a3f19f25843c4b36710200">
              <SHORT-NAME>ISDM_20ms_Group03</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDM_20ms_Group03_Reserved4</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAccV_SDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELatAcc_SDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAccV_SDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVSELongtAcc_SDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRateV_SDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDynYawRate_SDM</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group03</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b347d4dXOa505a3f19f25843c4b347d4c00">
              <SHORT-NAME>ITCM_020ms_PDU18</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICluActTorq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUAPAUnderCtrlA_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISCUDrvrIntrvnA_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve01</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve02</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_020ms_PDU18_Reserve03</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrAPACanclReq</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_020ms_PDU18</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b3416d3XOa505a3f19f25843c4b3416d200">
              <SHORT-NAME>ITCM_025ms_Group02</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocTrCmddGear_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlReqDndIO</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrShftCtrlTrgtGear_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved1</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved2</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_Group02_Reserved3</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU02_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrCrpMdA_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEPBAppReq</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdStaV_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEngdSta_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGearV_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrEstdGear_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrIntnlSwPosV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkPos</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrkSysF</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPosV_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftLvrPos_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrShftPtrnASts_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTapUpTapDwnMdSts_TCM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrTrgtShftLvrPos</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_025ms_Group02</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f5902a13b38331XNa505a3f19f5902a13b3832b00">
              <SHORT-NAME>ITCM_025ms_PDU20</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve01</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve02</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve03</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU20_Reserve04</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrACCToqReqResp</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_025ms_PDU20</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Na505a3f19f5902a13b37f4dXNa505a3f19f5902a13b37f4700">
              <SHORT-NAME>ITCM_PTCAN_FrP05</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITCM_025ms_PDU05_Reserve01</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGear</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrGearV</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqReqVal</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrImmdCrkshftToqRespTyp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqIntrvnTyp</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPrdtdCrkshftToqReqV</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_PTCAN_FrP05</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL-GROUP UUID="Oa505a3f19f25843c4b37c070XOa505a3f19f25843c4b37c06f00">
              <SHORT-NAME>ITDM_200ms_Group01</SHORT-NAME>
              <I-SIGNAL-REFS>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtF_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkLghtOn_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIO_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDircnIndLghtF_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIO_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDircnIndLghtF_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtF_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRevsLghtOn_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtF_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrFogLghtOn_TDM</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_CRC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_RC</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved103</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved111</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved119</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved127</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved15</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved27</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved39</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved47</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved55</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved63</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved71</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved79</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved87</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDM_200ms_Group01_Reserved95</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrlrCnctSts</I-SIGNAL-REF>
                <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehSideLghtSts_TDM</I-SIGNAL-REF>
              </I-SIGNAL-REFS>
              <SYSTEM-SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TDM_200ms_Group01</SYSTEM-SIGNAL-GROUP-REF>
            </I-SIGNAL-GROUP>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365d4eXOa505a3f19f25843c4b365d4d00">
              <SHORT-NAME>IABSA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Antilock Brake System Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL-B,ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:ABS激活状态
接收方描述:EDR ABS系统状态,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ABSA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ABSA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365d6dXOa505a3f19f25843c4b365d6c00">
              <SHORT-NAME>IABSF</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Antilock Brake System Fault</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:ABS错误状态
接收方描述:EDR ABS系统状态,ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ABSF</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ABSF</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSF</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b365d8cXOa505a3f19f25843c4b365d8b00">
              <SHORT-NAME>IABSIO</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Antilock Brake System Indication On</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ABS指示灯打开状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,SDM</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ABSIO</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ABSIO</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ABSIO</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fdfcXOa505a3f19f25843c4b37fdfb00">
              <SHORT-NAME>IACAmbtTem</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Ambient Temperature</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACAmbtTem</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACAmbtTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTem</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fe19XOa505a3f19f25843c4b37fe1800">
              <SHORT-NAME>IACAmbtTemMsk</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Ambient Temperature Mask</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:空调环境温度修正值可用性
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:IBS，空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACAmbtTemMsk</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACAmbtTemMsk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTemMsk</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fe35XOa505a3f19f25843c4b37fe3400">
              <SHORT-NAME>IACAmbtTemV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Ambient Temperature Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACAmbtTemV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACAmbtTemV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAmbtTemV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3786XOa505a3f19f25843c4b2e378500">
              <SHORT-NAME>IACAutoDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Auto Display Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACAutoDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACAutoDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACAutoDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a024XOa505a3f19f25843c4b36a02300">
              <SHORT-NAME>IACCAccReqSts_CH</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Acceleration Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ACC功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCAccReqSts_CH</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCAccReqSts_CH</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqSts_CH</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b561XOa505a3f19f25843c4b34b56000">
              <SHORT-NAME>IACCAccReqToqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Acceleration Request Torque Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group43
功能安全:
信息安全:
有无服务标签:null
发送方描述:行车制动扭矩请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCAccReqToqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCAccReqToqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqToqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a043XOa505a3f19f25843c4b36a04200">
              <SHORT-NAME>IACCAccReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Acceleration Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:
信息安全:
有无服务标签:
发送方描述:ACC功能使用
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCAccReqVal</SHORT-LABEL>
                  <VALUE>0x6B1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>11</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCAccReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCAccReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366716XOa505a3f19f25843c4b36671500">
              <SHORT-NAME>IACCBrkngA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Braking Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ACC制动状态
接收方描述:FVCM,PICU
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCBrkngA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCBrkngA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCBrkngA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9e82XOa505a3f19f25843c4b2e9e8100">
              <SHORT-NAME>IACCConfmSw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC confirm  switch</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCConfmSw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCConfmSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCConfmSw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7468XOa505a3f19f25843c4b2e746700">
              <SHORT-NAME>IACCConfmSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC confirm  switch request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCConfmSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCConfmSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCConfmSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9ea2XOa505a3f19f25843c4b2e9ea100">
              <SHORT-NAME>IACCCurveSpdSw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC curve speed switch</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCCurveSpdSw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCCurveSpdSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCCurveSpdSw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7487XOa505a3f19f25843c4b2e748600">
              <SHORT-NAME>IACCCurveSpdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC curve speed switch request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCCurveSpdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCCurveSpdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCCurveSpdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eebe4XOa505a3f19f25843c4b2eebe300">
              <SHORT-NAME>IACCDclReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Deceleration Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group15
功能安全:
信息安全:
有无服务标签:null
发送方描述:ACC减速请求状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDclReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDclReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDclReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9ec1XOa505a3f19f25843c4b2e9ec000">
              <SHORT-NAME>IACCDetObj1ExistPrblty</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Exist_Probability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1ExistPrblty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1ExistPrblty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9ee0XOa505a3f19f25843c4b2e9edf00">
              <SHORT-NAME>IACCDetObj1Id</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Identifier</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1Id</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1Id</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Id</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9effXOa505a3f19f25843c4b2e9efe00">
              <SHORT-NAME>IACCDetObj1LatRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Lateral_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1LatRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1LatRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LatRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9f1eXOa505a3f19f25843c4b2e9f1d00">
              <SHORT-NAME>IACCDetObj1LongtRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Longitudinal_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1LongtRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1LongtRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LongtRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9f3dXOa505a3f19f25843c4b2e9f3c00">
              <SHORT-NAME>IACCDetObj1LongtRltvSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Longitudinal_Relative_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1LongtRltvSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1LongtRltvSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LongtRltvSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9f5cXOa505a3f19f25843c4b2e9f5b00">
              <SHORT-NAME>IACCDetObj1Risk</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Risk</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1Risk</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1Risk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Risk</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9f7bXOa505a3f19f25843c4b2e9f7a00">
              <SHORT-NAME>IACCDetObj1SyncCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Synchronize_Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1SyncCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1SyncCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1SyncCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9f9aXOa505a3f19f25843c4b2e9f9900">
              <SHORT-NAME>IACCDetObj1Typ</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_1_Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj1Typ</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj1Typ</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Typ</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9fb9XOa505a3f19f25843c4b2e9fb800">
              <SHORT-NAME>IACCDetObj2ExistPrblty</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Exist_Probability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2ExistPrblty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2ExistPrblty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9fd8XOa505a3f19f25843c4b2e9fd700">
              <SHORT-NAME>IACCDetObj2Id</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Identifier</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2Id</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2Id</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Id</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9ff7XOa505a3f19f25843c4b2e9ff600">
              <SHORT-NAME>IACCDetObj2LatRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Lateral_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2LatRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2LatRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LatRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea016XOa505a3f19f25843c4b2ea01500">
              <SHORT-NAME>IACCDetObj2LongtRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Longitudinal_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2LongtRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2LongtRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LongtRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea035XOa505a3f19f25843c4b2ea03400">
              <SHORT-NAME>IACCDetObj2LongtRltvSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Longitudinal_Relative_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2LongtRltvSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2LongtRltvSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LongtRltvSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea054XOa505a3f19f25843c4b2ea05300">
              <SHORT-NAME>IACCDetObj2Risk</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Risk</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2Risk</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2Risk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Risk</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea073XOa505a3f19f25843c4b2ea07200">
              <SHORT-NAME>IACCDetObj2SyncCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Synchronize_Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2SyncCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2SyncCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2SyncCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea092XOa505a3f19f25843c4b2ea09100">
              <SHORT-NAME>IACCDetObj2Typ</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_2_Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj2Typ</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj2Typ</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Typ</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea0b1XOa505a3f19f25843c4b2ea0b000">
              <SHORT-NAME>IACCDetObj3ExistPrblty</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Exist_Probability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3ExistPrblty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3ExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3ExistPrblty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea0d0XOa505a3f19f25843c4b2ea0cf00">
              <SHORT-NAME>IACCDetObj3Id</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Identifier</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3Id</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3Id</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Id</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea0efXOa505a3f19f25843c4b2ea0ee00">
              <SHORT-NAME>IACCDetObj3LatRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Lateral_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3LatRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3LatRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LatRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea10eXOa505a3f19f25843c4b2ea10d00">
              <SHORT-NAME>IACCDetObj3LongtRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Longitudinal_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3LongtRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3LongtRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LongtRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea12dXOa505a3f19f25843c4b2ea12c00">
              <SHORT-NAME>IACCDetObj3LongtRltvSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Longitudinal_Relative_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3LongtRltvSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3LongtRltvSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LongtRltvSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea14cXOa505a3f19f25843c4b2ea14b00">
              <SHORT-NAME>IACCDetObj3Risk</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Risk</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3Risk</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3Risk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Risk</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea16bXOa505a3f19f25843c4b2ea16a00">
              <SHORT-NAME>IACCDetObj3SyncCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Synchronize_Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3SyncCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3SyncCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3SyncCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea18aXOa505a3f19f25843c4b2ea18900">
              <SHORT-NAME>IACCDetObj3Typ</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_3_Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObj3Typ</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObj3Typ</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Typ</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee696XOa505a3f19f25843c4b2ee69500">
              <SHORT-NAME>IACCDetObjDistLvl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Detected Object Distance Level</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjDistLvl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjDistLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjDistLvl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea1a9XOa505a3f19f25843c4b2ea1a800">
              <SHORT-NAME>IACCDetObjExistPrblty</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Exist_Probability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjExistPrblty</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjExistPrblty</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjExistPrblty</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c82eXOa505a3f19f25843c4b37c82d00">
              <SHORT-NAME>IACCDetObjHdngAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Detected Object Heading Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjHdngAng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjHdngAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjHdngAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea1c8XOa505a3f19f25843c4b2ea1c700">
              <SHORT-NAME>IACCDetObjId</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Identifier</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjId</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjId</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjId</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea1e7XOa505a3f19f25843c4b2ea1e600">
              <SHORT-NAME>IACCDetObjLatRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Lateral_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjLatRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjLatRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLatRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea206XOa505a3f19f25843c4b2ea20500">
              <SHORT-NAME>IACCDetObjLongtRltvDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Longitudinal_Relative_Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjLongtRltvDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjLongtRltvDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLongtRltvDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea225XOa505a3f19f25843c4b2ea22400">
              <SHORT-NAME>IACCDetObjLongtRltvSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Longitudinal_Relative_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjLongtRltvSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjLongtRltvSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLongtRltvSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea244XOa505a3f19f25843c4b2ea24300">
              <SHORT-NAME>IACCDetObjRisk</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_0_Risk</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjRisk</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjRisk</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjRisk</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea263XOa505a3f19f25843c4b2ea26200">
              <SHORT-NAME>IACCDetObjSyncCtr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_Synchronize_Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjSyncCtr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjSyncCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjSyncCtr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea282XOa505a3f19f25843c4b2ea28100">
              <SHORT-NAME>IACCDetObjTyp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Detected_Object_0_Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDetObjTyp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDetObjTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjTyp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee6b6XOa505a3f19f25843c4b2ee6b500">
              <SHORT-NAME>IACCDrvrSelTrgtSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Driver_Select_Target_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDrvrSelTrgtSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDrvrSelTrgtSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDrvrSelTrgtSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f3a1b413231ddfXNa505a3f19f3a1b413231dce00">
              <SHORT-NAME>IACCDrvrTkovReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Driver_Takeover_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:ACC接管请求
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCDrvrTkovReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCDrvrTkovReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDrvrTkovReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee6d6XOa505a3f19f25843c4b2ee6d500">
              <SHORT-NAME>IACCGoNotfr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Go_Notifier</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCGoNotfr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCGoNotfr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoNotfr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a062XOa505a3f19f25843c4b36a06100">
              <SHORT-NAME>IACCGoReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Go Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ACC功能使用
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCGoReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCGoReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCGoReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee6f6XOa505a3f19f25843c4b2ee6f500">
              <SHORT-NAME>IACCMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>5</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c865XOa505a3f19f25843c4b37c86400">
              <SHORT-NAME>IACCObjDet</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Object Detected</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCObjDet</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCObjDet</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCObjDet</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322d8fXOa505a3f19f25843c4b322d8e00">
              <SHORT-NAME>IACCOtptShaftTotToqReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Output Shaft Total Torque Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20
Signal Group:ICBAD_20ms_Group15
功能安全:
信息安全:
有无服务标签:null
发送方描述:ACC扭矩请求状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCOtptShaftTotToqReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCOtptShaftTotToqReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b322daeXOa505a3f19f25843c4b322dad00">
              <SHORT-NAME>IACCOtptShaftTotToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Output Shaft Total Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20
Signal Group:ICBAD_20ms_Group15
功能安全:
信息安全:
有无服务标签:null
发送方描述:ACC扭矩请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCOtptShaftTotToqReqVal</SHORT-LABEL>
                  <VALUE>0x6A0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCOtptShaftTotToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCOtptShaftTotToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a081XOa505a3f19f25843c4b36a08000">
              <SHORT-NAME>IACCSdslReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Standstill Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ACC功能使用
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSdslReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSdslReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSdslReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee716XOa505a3f19f25843c4b2ee71500">
              <SHORT-NAME>IACCSeldTrgtDistLvl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Selected_Target_Distance_Level</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSeldTrgtDistLvl</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSeldTrgtDistLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSeldTrgtDistLvl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea2a1XOa505a3f19f25843c4b2ea2a000">
              <SHORT-NAME>IACCSpdLimtSw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC speed limit swtich</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSpdLimtSw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSpdLimtSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSpdLimtSw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e74a6XOa505a3f19f25843c4b2e74a500">
              <SHORT-NAME>IACCSpdLimtSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC speed limit swtich request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSpdLimtSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSpdLimtSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSpdLimtSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea2c0XOa505a3f19f25843c4b2ea2bf00">
              <SHORT-NAME>IACCStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea2dfXOa505a3f19f25843c4b2ea2de00">
              <SHORT-NAME>IACCStsSw</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC status switch</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCStsSw</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCStsSw</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsSw</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e74c5XOa505a3f19f25843c4b2e74c400">
              <SHORT-NAME>IACCStsSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ACC status switch request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCStsSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCStsSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a0a0XOa505a3f19f25843c4b36a09f00">
              <SHORT-NAME>IACCSysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control System Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:ACC功能使用
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b57cXOa505a3f19f25843c4b34b57b00">
              <SHORT-NAME>IACCSysFltSts_SCS</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_System_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group43
功能安全:
信息安全:
有无服务标签:null
发送方描述:智驾拉起EPB
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾、IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSysFltSts_SCS</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSysFltSts_SCS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysFltSts_SCS</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a0bfXOa505a3f19f25843c4b36a0be00">
              <SHORT-NAME>IACCSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:高速智驾状态‘,ACC功能使用
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee736XOa505a3f19f25843c4b2ee73500">
              <SHORT-NAME>IACCTJAMdSwDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Traffic_Jam_Assist_Mode_Switch_Display_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:LCC软开关显示状态
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCTJAMdSwDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCTJAMdSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTJAMdSwDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e74e4XOa505a3f19f25843c4b2e74e300">
              <SHORT-NAME>IACCTJAMdSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive_Cruise_Control_Traffic_Jam_Assist_Mode_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LCC软开关设置请求
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCTJAMdSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCTJAMdSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTJAMdSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376cceXOa505a3f19f25843c4b376ccd00">
              <SHORT-NAME>IACCToqReqSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBAD_ZONE_20ms_Group13
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCToqReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCToqReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376ce5XOa505a3f19f25843c4b376ce400">
              <SHORT-NAME>IACCToqReqVal</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:ICBAD_ZONE_20ms_Group13
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCToqReqVal</SHORT-LABEL>
                  <VALUE>0x6A0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee756XOa505a3f19f25843c4b2ee75500">
              <SHORT-NAME>IACCTotWhlToqReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Total Wheel Torque Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCTotWhlToqReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCTotWhlToqReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ee776XOa505a3f19f25843c4b2ee77500">
              <SHORT-NAME>IACCTotWhlToqReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Adaptive Cruise Control Total Wheel Torque Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:FVCM_20ms_Group02
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACCTotWhlToqReqVal</SHORT-LABEL>
                  <VALUE>0x7530</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACCTotWhlToqReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTotWhlToqReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fe51XOa505a3f19f25843c4b37fe5000">
              <SHORT-NAME>IACComprActuPwr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Compressor Actual Power</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:RHZCU_100ms_Group10
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACComprActuPwr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACComprActuPwr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACComprActuPwr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3939XOa505a3f19f25843c4b2e393800">
              <SHORT-NAME>IACFrtBlwrSpdDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Front Blower Speed Display Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACFrtBlwrSpdDspCmd</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACFrtBlwrSpdDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACFrtBlwrSpdDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3a11XOa505a3f19f25843c4b2e3a1000">
              <SHORT-NAME>IACLAirMdDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning Left Air Mode Display Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACLAirMdDspCmd</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACLAirMdDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACLAirMdDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3a4fXOa505a3f19f25843c4b2e3a4e00">
              <SHORT-NAME>IACOnOffDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning On Off Display Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:ESS，空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACOnOffDspCmd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACOnOffDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACOnOffDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7522XOa505a3f19f25843c4b2e752100">
              <SHORT-NAME>IACSFCatgrAStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category A Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrAStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrAStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrAStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea2feXOa505a3f19f25843c4b2ea2fd00">
              <SHORT-NAME>IACSFCatgrB1StsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category B1 Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrB1StsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrB1StsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrB1StsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e725cXOa505a3f19f25843c4b2e725b00">
              <SHORT-NAME>IACSFCatgrB2StsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category B2 Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrB2StsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrB2StsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrB2StsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea31dXOa505a3f19f25843c4b2ea31c00">
              <SHORT-NAME>IACSFCatgrCStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category C Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrCStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrCStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrCStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea33cXOa505a3f19f25843c4b2ea33b00">
              <SHORT-NAME>IACSFCatgrDStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category D Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrDStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrDStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrDStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea35bXOa505a3f19f25843c4b2ea35a00">
              <SHORT-NAME>IACSFCatgrEStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Automatically Commanded Steering Function Category E Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACSFCatgrEStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACSFCatgrEStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrEStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7541XOa505a3f19f25843c4b2e754000">
              <SHORT-NAME>IACUserCustAftRunOnOffR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization After Run On Off Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustAftRunOnOffR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustAftRunOnOffR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustAftRunOnOffR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e7560XOa505a3f19f25843c4b2e755f00">
              <SHORT-NAME>IACUserCustAftRunOnOffReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization After Run On Off Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustAftRunOnOffReqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustAftRunOnOffReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustAftRunOnOffReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e757fXOa505a3f19f25843c4b2e757e00">
              <SHORT-NAME>IACUserCustAutoMdBlwrReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization Auto Mode Blower Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustAutoMdBlwrReq</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustAutoMdBlwrReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustAutoMdBlwrReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e759eXOa505a3f19f25843c4b2e759d00">
              <SHORT-NAME>IACUserCustAutoMdBlwrReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization Auto Mode Blower Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调,PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustAutoMdBlwrReqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustAutoMdBlwrReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustAutoMdBlwrReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e75bdXOa505a3f19f25843c4b2e75bc00">
              <SHORT-NAME>IACUserCustEcoSetngReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization Economy Setting Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustEcoSetngReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustEcoSetngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustEcoSetngReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e75dcXOa505a3f19f25843c4b2e75db00">
              <SHORT-NAME>IACUserCustEcoSetngReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Air Conditioning User Customization Economy Setting Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:空调</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ACUserCustEcoSetngReqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ACUserCustEcoSetngReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACUserCustEcoSetngReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e16b1XOa505a3f19f25843c4b2e16b000">
              <SHORT-NAME>IADASStrgDlvrdToq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Driver Assistance System Steering Delivered Torque</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:ADAS扭矩
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADASStrgDlvrdToq</SHORT-LABEL>
                  <VALUE>0x400</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>11</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADASStrgDlvrdToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e16d0XOa505a3f19f25843c4b2e16cf00">
              <SHORT-NAME>IADASStrgDlvrdToqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Advanced Driver Assistance System Steering Delivered Torque Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:EPS_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:ADAS扭矩有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADASStrgDlvrdToqV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADASStrgDlvrdToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADASStrgDlvrdToqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e75fbXOa505a3f19f25843c4b2e75fa00">
              <SHORT-NAME>IADAudioSWReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AD audio switch request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADAudioSWReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADAudioSWReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADAudioSWReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea37aXOa505a3f19f25843c4b2ea37900">
              <SHORT-NAME>IADAudioSWSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AD audio switch status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADAudioSWSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADAudioSWSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADAudioSWSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380140XOa505a3f19f25843c4b38013f00">
              <SHORT-NAME>IADS_ISAMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ADAS_Intelligence_Speed_Assist _System_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ISA提醒
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADS_ISAMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADS_ISAMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISAMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380159XOa505a3f19f25843c4b38015800">
              <SHORT-NAME>IADS_ISASysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ADAS_Intelligence_Speed_Assist _System_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ISA故障状态
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADS_ISASysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADS_ISASysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISASysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b38010eXOa505a3f19f25843c4b38010d00">
              <SHORT-NAME>IADS_ISASysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ADAS_Intelligence_Speed_Assist _System_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ISA状态信号
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADS_ISASysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADS_ISASysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISASysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37f855XOa505a3f19f25843c4b37f85400">
              <SHORT-NAME>IADS_SpdAstSysTrgtSpd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ADAS_Speed_Assist_System_Target_Speed</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group67
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:SLIF智能速度辅助融合限速值给动力域
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADS_SpdAstSysTrgtSpd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>15</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADS_SpdAstSysTrgtSpd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37f870XOa505a3f19f25843c4b37f86f00">
              <SHORT-NAME>IADS_SpdAstSysTrgtSpdV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">ADAS_Speed_Assist_System_Target_Speed Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IPD_20ms_Group67
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:ISA限速值有效位
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ADS_SpdAstSysTrgtSpdV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ADS_SpdAstSysTrgtSpdV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_SpdAstSysTrgtSpdV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a362XOa505a3f19f25843c4b36a36100">
              <SHORT-NAME>IAEBBrkJerkLvlReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Brake Jerk Level Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:AEB功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBBrkJerkLvlReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBBrkJerkLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBBrkJerkLvlReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a381XOa505a3f19f25843c4b36a38000">
              <SHORT-NAME>IAEBDclReqSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL-B,ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:AEB请求状态
接收方描述:IBS
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b7b7XOa505a3f19f25843c4b34b7b600">
              <SHORT-NAME>IAEBDclReqSts_ADAS</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RFSDA_20ms_Group02
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:AEB请求状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqSts_ADAS</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqSts_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqSts_ADAS</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3237b7XOa505a3f19f25843c4b3237b600">
              <SHORT-NAME>IAEBDclReqToqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Torque Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:null
发送方描述:AEB制动扭矩请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqToqVal</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqToqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqToqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b7d2XOa505a3f19f25843c4b34b7d100">
              <SHORT-NAME>IAEBDclReqToqVal_ADAS</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Torque Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RFSDA_20ms_Group02
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:AEB制动扭矩请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqToqVal_ADAS</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqToqVal_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqToqVal_ADAS</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a3a0XOa505a3f19f25843c4b36a39f00">
              <SHORT-NAME>IAEBDclReqVal</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:AEB请求
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqVal</SHORT-LABEL>
                  <VALUE>0x7F</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqVal</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b7edXOa505a3f19f25843c4b34b7ec00">
              <SHORT-NAME>IAEBDclReqVal_ADAS</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Deceleration Request Value</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:RFSDA_20ms_Group02
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:AEB请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDclReqVal_ADAS</SHORT-LABEL>
                  <VALUE>0x7F</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDclReqVal_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDclReqVal_ADAS</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea399XOa505a3f19f25843c4b2ea39800">
              <SHORT-NAME>IAEBDspCmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous_Emergency_Braking_Display_Command</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AEB开关显示
接收方描述:ZXD
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBDspCmd</SHORT-LABEL>
                  <VALUE>0x2</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDspCmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a3bfXOa505a3f19f25843c4b36a3be00">
              <SHORT-NAME>IAEBHydBrkAstLvlReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Hydraulic Brake Assist Level Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:AEB功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBHydBrkAstLvlReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBHydBrkAstLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBHydBrkAstLvlReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea3b8XOa505a3f19f25843c4b2ea3b700">
              <SHORT-NAME>IAEBMsgReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous_Emergency_Braking_Message_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AEB文言信息
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBMsgReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBMsgReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a3deXOa505a3f19f25843c4b36a3dd00">
              <SHORT-NAME>IAEBPrflReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Prefill Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:AEB功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBPrflReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBPrflReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBPrflReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ea3d7XOa505a3f19f25843c4b2ea3d600">
              <SHORT-NAME>IAEBStsForEdr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking Status For Edr</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:null
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBStsForEdr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBStsForEdr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e761aXOa505a3f19f25843c4b2e761900">
              <SHORT-NAME>IAEBSwReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous_Emergency_Braking_Switch_Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AEB软开关请求
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBSwReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSwReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a3fdXOa505a3f19f25843c4b36a3fc00">
              <SHORT-NAME>IAEBSysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking System Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:AEB功能使用
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBSysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36a41cXOa505a3f19f25843c4b36a41b00">
              <SHORT-NAME>IAEBSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Autonomous Emergency Braking System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:ICBAD_20ms_Group46
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:AEB功能使用
接收方描述:IBS
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:SDM,IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AEBSysSts</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AEBSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3238e9XOa505a3f19f25843c4b3238e800">
              <SHORT-NAME>IAGS1FltRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AGS1 Fault Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:AGS1故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGS1FltRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGS1FltRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGS1FltRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323908XOa505a3f19f25843c4b32390700">
              <SHORT-NAME>IAGS2FltRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">AGS2 Fault Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:AGS2故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGS2FltRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGS2FltRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGS2FltRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a1e1XOa505a3f19f25843c4b31a1e000">
              <SHORT-NAME>IAGSActualPosition1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Actual Position 1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS1实际位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSActualPosition1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSActualPosition1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSActualPosition1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a200XOa505a3f19f25843c4b31a1ff00">
              <SHORT-NAME>IAGSActualPosition2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Actual Position 2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS2实际位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSActualPosition2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSActualPosition2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSActualPosition2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a23eXOa505a3f19f25843c4b31a23d00">
              <SHORT-NAME>IAGSModestatus1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Mode Status 1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS1模式位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSModestatus1</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSModestatus1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSModestatus1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a2baXOa505a3f19f25843c4b31a2b900">
              <SHORT-NAME>IAGSModestatus2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Mode Status 2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:AGS2模式位置
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:热管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>AGSModestatus2</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/AGSModestatus2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AGSModestatus2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31a336XOa505a3f19f25843c4b31a33500">
              <SHORT-NAME>IAGSMoveStatus1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Aero Grille Shutter Move Status 1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
