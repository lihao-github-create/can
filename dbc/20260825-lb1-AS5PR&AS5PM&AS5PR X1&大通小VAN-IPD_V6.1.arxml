                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PrvOutSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="047a1e6f17303b0db875848d7e3319fe">
                  <SHORT-NAME>PwrDMd_enum_IPD_PwrDMd_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PwrDMd_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PwrDMd_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d356d32c359e3b7d883e34ad05e47f6e">
                  <SHORT-NAME>PwrReq_flg_IPD_PwrReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PwrReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PwrReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="769fd137a1093b53a4403bd0f5c865bb">
                  <SHORT-NAME>RAAlrWorDis_IPD_RAAlrWorDis</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RAAlrWorDis</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RAAlrWorDis</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4b48242b2e86325c827ba0fdfe37d820">
                  <SHORT-NAME>RACtlReq_IPD_RACtlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RACtlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RACtlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c05a1a0779937f8bae8bf27dc961b27">
                  <SHORT-NAME>RADSSwSts_IPD_RADSSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RADSSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RADSSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b9da2e004e03352a8058182e377627b">
                  <SHORT-NAME>RASysSts_IPD_RASysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RASysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RASysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d82f3d79a511369a8804a7532516e547">
                  <SHORT-NAME>RCTSysSelReq_IPD_RCTSysSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RCTSysSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RCTSysSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="923797049ffc353e8f1ae796ccf4459a">
                  <SHORT-NAME>RCWSelReq_IPD_RCWSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RCWSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RCWSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ea0fa378595b31419c7738511dfc34cb">
                  <SHORT-NAME>RDASwReq_IPD_RDASwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RDASwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RDASwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="00638aa1b6f439b6b9a1e30a30926645">
                  <SHORT-NAME>RFCTWrnng_ADAS_IPD_RFCTWrnng_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RFCTWrnng_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFCTWrnng_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7f46f1903fb43c4fa7d026b792bcc34b">
                  <SHORT-NAME>RFCTWrnng_IPD_RFCTWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RFCTWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFCTWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a4721fb3d5e63f618dd12253c276c2f0">
                  <SHORT-NAME>RFSDA_20ms_Group02_IPD_RFSDA_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RFSDA_20ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFSDA_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d565dc816bf4396d881423b19ad02f69">
                  <SHORT-NAME>RHRDA_50ms_Group04_IPD_RHRDA_50ms_Group04</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHRDA_50ms_Group04</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHRDA_50ms_Group04</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4b83bd68fb593f3eb2491d001b5462a6">
                  <SHORT-NAME>RHZCUAvlbly_IPD_RHZCUAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHZCUAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCUAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d894aed213e388dbe31810985e17979">
                  <SHORT-NAME>RHZCU_100ms_Group10_IPD_RHZCU_100ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHZCU_100ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_100ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="37bd3fcab36830c08568db0353dc04e7">
                  <SHORT-NAME>RHZCU_50ms_Group01_IPD_RHZCU_50ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHZCU_50ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_50ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="69ae0387756e3705bbb3f55ea5dccfbc">
                  <SHORT-NAME>RHZCU_50ms_Group27_IPD_RHZCU_50ms_Group27</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHZCU_50ms_Group27</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_50ms_Group27</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a0c663e2e1132818328a138d9891f57">
                  <SHORT-NAME>RHZCUeFs1Sts_IPD_RHZCUeFs1Sts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RHZCUeFs1Sts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCUeFs1Sts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e1e6b0c6c1a13fc88b16a66df28ff2e9">
                  <SHORT-NAME>RLObsRng_IPD_RLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34c67114bf92301bbfc1f2f98c2f8639">
                  <SHORT-NAME>RLSObsRng_IPD_RLSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f833734d025303088035812f680463a">
                  <SHORT-NAME>RLSUSSSts_IPD_RLSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="24e177a28c6e37908765bf8c8f87b228">
                  <SHORT-NAME>RLSideObsRng_IPD_RLSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="090056a778e337d1b82c13f9f8a770eb">
                  <SHORT-NAME>RLTirePrsV_IPD_RLTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e66d4f97a8330a48729f021ff11b9ae">
                  <SHORT-NAME>RLTirePrs_IPD_RLTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d0cafca2fb03a8592eb3a320111be80">
                  <SHORT-NAME>RLTireSts_IPD_RLTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93051f5378f3369984e5e63aa1f9dbef">
                  <SHORT-NAME>RLTireTemV_IPD_RLTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e0fd7fcb2eb3f6fbdc3de135bd9c118">
                  <SHORT-NAME>RLTireTem_IPD_RLTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b49ae7dc51936529ecb50f40fd5aa19">
                  <SHORT-NAME>RLUSSSts_IPD_RLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a70ba7967fb537a699ac50ecc9a392b2">
                  <SHORT-NAME>RMLUSSSts_IPD_RMLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RMLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RMLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3bafa7a64ddf3e6b8fbd3036ae3b5e11">
                  <SHORT-NAME>RMRUSSSts_IPD_RMRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RMRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RMRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9fd7084d88863385bb5bbf3ae80ec97e">
                  <SHORT-NAME>RPShockDistL_IPD_RPShockDistL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RPShockDistL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RPShockDistL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="918090d2712337dfaea351d9bee7844a">
                  <SHORT-NAME>RPShockDistR_IPD_RPShockDistR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RPShockDistR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RPShockDistR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dc3074f2d14332b186c2cb3772162057">
                  <SHORT-NAME>RRObsRng_IPD_RRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa3b7ccab31b3b678e4cf8afc260fcfa">
                  <SHORT-NAME>RRSObsRng_IPD_RRSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e05bda2d9d5b30609a95215661185e3b">
                  <SHORT-NAME>RRSUSSSts_IPD_RRSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="24d7fdf892f73b12b5f3f958d6912db1">
                  <SHORT-NAME>RRSideObsRng_IPD_RRSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b0276b7aaeab3906adc502804721b4c9">
                  <SHORT-NAME>RRTirePrsV_IPD_RRTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e54da68412a03139a5654502f1920fdc">
                  <SHORT-NAME>RRTirePrs_IPD_RRTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c35ceaf6fee0381a9af2891fb11c34db">
                  <SHORT-NAME>RRTireSts_IPD_RRTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="da3972af13ba326a9f28c4b4b4c1448f">
                  <SHORT-NAME>RRTireTemV_IPD_RRTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0f0ea564c51328da38b000a553b308c">
                  <SHORT-NAME>RRTireTem_IPD_RRTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1983536974ba3211aa29a05bc794b901">
                  <SHORT-NAME>RRUSSSts_IPD_RRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a6792a2aabd43383bdf02a16b9896b77">
                  <SHORT-NAME>RZCUIgnDiagSts_IPD_RZCUIgnDiagSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCUIgnDiagSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCUIgnDiagSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d6dee459e4923b3abab82dd41ea6bdf1">
                  <SHORT-NAME>RZCUIgnSts_IPD_RZCUIgnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCUIgnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCUIgnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e77d96e184934d6bdd34163277737e5">
                  <SHORT-NAME>RZCU_100ms_Group10_IPD_RZCU_100ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_100ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_100ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5b13937315cf3d14912eaa32c92e8599">
                  <SHORT-NAME>RZCU_10ms_Group01_IPD_RZCU_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9c121d8a8b7372ba8c456e4ac100ae1">
                  <SHORT-NAME>RZCU_10ms_Group02_IPD_RZCU_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d4ad6c3d5f832fa846831947052b049">
                  <SHORT-NAME>RZCU_10ms_Group22_IPD_RZCU_10ms_Group22</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group22</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group22</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="940b52102d083c93ba078b711d3f9384">
                  <SHORT-NAME>RZCU_10ms_Group23_IPD_RZCU_10ms_Group23</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group23</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group23</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3b9e200f739c384faa40e5d351847e29">
                  <SHORT-NAME>RZCU_10ms_Group24_IPD_RZCU_10ms_Group24</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group24</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group24</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c6f26d3d3ba35f895529e43ce7f8f27">
                  <SHORT-NAME>RZCU_10ms_Group90_IPD_RZCU_10ms_Group90</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_10ms_Group90</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group90</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9aa76c70bde23c5690c814d5eec0aa95">
                  <SHORT-NAME>RZCU_20ms_Group06_IPD_RZCU_20ms_Group06</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_20ms_Group06</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_20ms_Group06</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db88449346a4339b90e508734476bc01">
                  <SHORT-NAME>RZCU_50ms_Group37_IPD_RZCU_50ms_Group37</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_50ms_Group37</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_50ms_Group37</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7c84aeeede23f09b128bd0964174e98">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly_IPD_RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_BKBCANFDAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_BKBCANFDAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3364bb841a9a34d7b9378ca1fc3dd466">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64_IPD_RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RZCU_ZONE_10ms_Group64</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_ZONE_10ms_Group64</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e8f3a8d4605374688af5f0f081c7493">
                  <SHORT-NAME>ResetCnt_IPD_ResetCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ResetCnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ResetCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2295360d70d4375a9422a80a19e50aa5">
                  <SHORT-NAME>RoadHeightL_IPD_RoadHeightL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadHeightL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadHeightL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ed3356e1b033d4f9fecdc85c458d103">
                  <SHORT-NAME>RoadHeightR_IPD_RoadHeightR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadHeightR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadHeightR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="44761d56f2203a82bbb8e9cb7860ae1d">
                  <SHORT-NAME>RoadProfileShockConfidenceL1_IPD_RoadProfileShockConfidenceL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="95855c1306a639888685713489420933">
                  <SHORT-NAME>RoadProfileShockConfidenceL2_IPD_RoadProfileShockConfidenceL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b1c555cbbccf3bf88cf54650fe45ee8d">
                  <SHORT-NAME>RoadProfileShockConfidenceL3_IPD_RoadProfileShockConfidenceL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b11aaaf028e23314a4135259c5544e4b">
                  <SHORT-NAME>RoadProfileShockConfidenceL_IPD_RoadProfileShockConfidenceL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8e89b59f188b31dbaec02e5e35f1d4b0">
                  <SHORT-NAME>RoadProfileShockConfidenceR1_IPD_RoadProfileShockConfidenceR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="38612b45a8373db5b65eccf41f574f41">
                  <SHORT-NAME>RoadProfileShockConfidenceR2_IPD_RoadProfileShockConfidenceR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f143dd6a6f80335295b12fb58251c5a9">
                  <SHORT-NAME>RoadProfileShockConfidenceR3_IPD_RoadProfileShockConfidenceR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b70fb821a8f33d16bc872fdfec5ca532">
                  <SHORT-NAME>RoadProfileShockConfidenceR_IPD_RoadProfileShockConfidenceR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockConfidenceR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="342d7b9274d938389a3747a22df9ec64">
                  <SHORT-NAME>RoadProfileShockDetectedL1_IPD_RoadProfileShockDetectedL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="885f38760a1531c5a44beca3a916477b">
                  <SHORT-NAME>RoadProfileShockDetectedL2_IPD_RoadProfileShockDetectedL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5ae3180e6e0c3654b25e85b903758fca">
                  <SHORT-NAME>RoadProfileShockDetectedL3_IPD_RoadProfileShockDetectedL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3ef9530bed85322e80e66d5388ac04c6">
                  <SHORT-NAME>RoadProfileShockDetectedL_IPD_RoadProfileShockDetectedL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b72c21f2f1f3c7291b716977aa197f1">
                  <SHORT-NAME>RoadProfileShockDetectedR1_IPD_RoadProfileShockDetectedR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25d711a2491f3200b12d06101f2499ff">
                  <SHORT-NAME>RoadProfileShockDetectedR2_IPD_RoadProfileShockDetectedR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7483054eab13346823dc27acc7c334a">
                  <SHORT-NAME>RoadProfileShockDetectedR3_IPD_RoadProfileShockDetectedR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="af50ef5a3b64381aaf42f2ede84a0d51">
                  <SHORT-NAME>RoadProfileShockDetectedR_IPD_RoadProfileShockDetectedR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDetectedR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c4cc559f402239cc927e9cd3c9034e10">
                  <SHORT-NAME>RoadProfileShockDistL1_IPD_RoadProfileShockDistL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25a7f5622cd9381abecd5604d1f90277">
                  <SHORT-NAME>RoadProfileShockDistL2_IPD_RoadProfileShockDistL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bbf6bb1805c5337e9444a89d66780ad8">
                  <SHORT-NAME>RoadProfileShockDistL3_IPD_RoadProfileShockDistL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e81d3b80e85301ebcc74ed88b2937d8">
                  <SHORT-NAME>RoadProfileShockDistR1_IPD_RoadProfileShockDistR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="931ce9c3af013fa395d79b72f4f39082">
                  <SHORT-NAME>RoadProfileShockDistR2_IPD_RoadProfileShockDistR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca696dfdecb63c368d0ec24b420fe6ee">
                  <SHORT-NAME>RoadProfileShockDistR3_IPD_RoadProfileShockDistR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockDistR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="df65e2f7c671373dbeed4ab9b4a0f3b6">
                  <SHORT-NAME>RoadProfileShockHeightL1_IPD_RoadProfileShockHeightL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7a3454e67243940bb4857be4f8e5d09">
                  <SHORT-NAME>RoadProfileShockHeightL2_IPD_RoadProfileShockHeightL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f0dc3d3b674a362c864038b496fae844">
                  <SHORT-NAME>RoadProfileShockHeightL3_IPD_RoadProfileShockHeightL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cb21274de52f30f5a9ded29abd5252bf">
                  <SHORT-NAME>RoadProfileShockHeightL_IPD_RoadProfileShockHeightL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b4fad126c9a73a31a36ee4bc63445d92">
                  <SHORT-NAME>RoadProfileShockHeightR1_IPD_RoadProfileShockHeightR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="818b3abafab53418a4e3a9331681121e">
                  <SHORT-NAME>RoadProfileShockHeightR2_IPD_RoadProfileShockHeightR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc3e3253fe30345fa94795369d3ad5bd">
                  <SHORT-NAME>RoadProfileShockHeightR3_IPD_RoadProfileShockHeightR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9eab03ffb9f030d8b08ba710529cd507">
                  <SHORT-NAME>RoadProfileShockHeightR_IPD_RoadProfileShockHeightR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockHeightR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a0f831724203d7dba2eb2a06f1b97dd">
                  <SHORT-NAME>RoadProfileShockLevelL_IPD_RoadProfileShockLevelL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockLevelL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockLevelL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f70fd90a7e5e34829ee8a249bc01e181">
                  <SHORT-NAME>RoadProfileShockLevelR_IPD_RoadProfileShockLevelR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RoadProfileShockLevelR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockLevelR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="20a78f07765a3b0c861a40ac5437c2b7">
                  <SHORT-NAME>Rolloff2Min_flg_IPD_Rolloff2Min_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Rolloff2Min_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Rolloff2Min_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="089a17c6c0bf317b9b9e31ec1fcc7a0c">
                  <SHORT-NAME>RolloffHld_flg_IPD_RolloffHld_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RolloffHld_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RolloffHld_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b690e63d600d33528259a96fd10142d5">
                  <SHORT-NAME>RrMidLObsRng_IPD_RrMidLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RrMidLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrMidLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d42520d8d1d533c1964cc9054a3047e1">
                  <SHORT-NAME>RrMidRObsRng_IPD_RrMidRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RrMidRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrMidRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b61d2dbc52634d9bcaf63ace101bdf6">
                  <SHORT-NAME>RrObsDist_IPD_RrObsDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RrObsDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrObsDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="36434a4f424532fb9142991e3abeb9db">
                  <SHORT-NAME>RrPDCAudWrnng_IPD_RrPDCAudWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RrPDCAudWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrPDCAudWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="695df18723a73fac86a8457c97dd8d4f">
                  <SHORT-NAME>RrTireStdPrs_IPD_RrTireStdPrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RrTireStdPrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrTireStdPrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cf30191302273b7c82e43b37f1b7c37a">
                  <SHORT-NAME>RstrFctryDeftsReq_IPD_RstrFctryDeftsReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/RstrFctryDeftsReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RstrFctryDeftsReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="16b2b230f8723363b4930fb43c7c9586">
                  <SHORT-NAME>SDMAvlbly_IPD_SDMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SDMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c426b6e19c0c3271b787a20e10abfe68">
                  <SHORT-NAME>SDM_20ms_Group01_IPD_SDM_20ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SDM_20ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c01fade949543ad7ae91f90cc2682e89">
                  <SHORT-NAME>SDM_20ms_Group02_IPD_SDM_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SDM_20ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d37bfef6e6e3bc5bc30211dc77787bf">
                  <SHORT-NAME>SDM_20ms_Group03_IPD_SDM_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SDM_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7725a52077f935ceb55dbf73defb49b3">
                  <SHORT-NAME>SLIFAudWrnng_IPD_IPD_SLIFAudWrnng_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFAudWrnng_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFAudWrnng_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d8dd2591331538bc83ac2974d65c6dc0">
                  <SHORT-NAME>SLIFSts_IPD_IPD_SLIFSts_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFSts_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFSts_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9f48ebab30e3d6a97fedb59bb89ffe4">
                  <SHORT-NAME>SLIFSysFltSts_IPD_SLIFSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c96ea682cda3b82ac2c73dd21e50608">
                  <SHORT-NAME>SLIFUpdtIndReq_IPD_SLIFUpdtIndReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFUpdtIndReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtIndReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e6256e762fff30a4aa1bc725fd68571a">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD_IPD_SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFUpdtIndResp_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtIndResp_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce578499c9eb327980bcbec4a07d3f4d">
                  <SHORT-NAME>SLIFUpdtInd_IPD_IPD_SLIFUpdtInd_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFUpdtInd_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtInd_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a4982e9bd8f536a285226f4fbd6937e4">
                  <SHORT-NAME>SLIFWrnngMdReq_IPD_SLIFWrnngMdReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFWrnngMdReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFWrnngMdReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="582c513b13c23ddebd4397b0f4f1c553">
                  <SHORT-NAME>SLIFWrnngMdResp_IPD_SLIFWrnngMdResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SLIFWrnngMdResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFWrnngMdResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3d6a99230b6231bb96dbd30273dbe427">
                  <SHORT-NAME>SOCLowPwrDwn_flg_IPD_SOCLowPwrDwn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SOCLowPwrDwn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCLowPwrDwn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="915c7247a0363dbe8af22d4f6efbcab5">
                  <SHORT-NAME>SOCLvl_enum_IPD_SOCLvl_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SOCLvl_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCLvl_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed1d44bad4f332a282e7c33984edf759">
                  <SHORT-NAME>SOCMd_enum_IPD_SOCMd_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SOCMd_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCMd_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c64738af10253eeb8a0c2f9e9fe698d9">
                  <SHORT-NAME>SatAz10_IPD_SatAz10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cba56170eddb35cb890763eb0530ac03">
                  <SHORT-NAME>SatAz11_IPD_SatAz11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a825a778cb43f15b8c730599f0d19b8">
                  <SHORT-NAME>SatAz12_IPD_SatAz12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="41c5b2ac7f013a28a2ce3bcf20198ca9">
                  <SHORT-NAME>SatAz13_IPD_SatAz13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3981c873ac343ac592190cf794b3cde1">
                  <SHORT-NAME>SatAz14_IPD_SatAz14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9ffd78ddb9483db2b70658cb3eab9624">
                  <SHORT-NAME>SatAz15_IPD_SatAz15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7125257b52d53cf9a677fe24da70338a">
                  <SHORT-NAME>SatAz16_IPD_SatAz16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db11922f2df83802b0ed3ebb70625b37">
                  <SHORT-NAME>SatAz17_IPD_SatAz17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a11d5040cc5323b86b581e7986927c5">
                  <SHORT-NAME>SatAz18_IPD_SatAz18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59880ae205143f4eb3b2521020050566">
                  <SHORT-NAME>SatAz19_IPD_SatAz19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3407bc2f8ce230b684a8bfa1d8c36fa0">
                  <SHORT-NAME>SatAz1_IPD_SatAz1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a79baa54e2f340e99f99d7cac8b48ac">
                  <SHORT-NAME>SatAz20_IPD_SatAz20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="768471782b8037e889c359331702957f">
                  <SHORT-NAME>SatAz2_IPD_SatAz2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57e05fb798e135e8b5f8f68df7dc9c0a">
                  <SHORT-NAME>SatAz3_IPD_SatAz3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5be582afc22234068442b5aa5afc5074">
                  <SHORT-NAME>SatAz4_IPD_SatAz4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b5653bf1ed231588504226894d93f0b">
                  <SHORT-NAME>SatAz5_IPD_SatAz5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e0850c16809f30a38a047c278f6182a1">
                  <SHORT-NAME>SatAz6_IPD_SatAz6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e87fd50b2c6d3b70b9dcb0313d374a59">
                  <SHORT-NAME>SatAz7_IPD_SatAz7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e0adac60ca23defac5bb99ebf69215d">
                  <SHORT-NAME>SatAz8_IPD_SatAz8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4458117dec2c36a5bbb0ceb704a2507b">
                  <SHORT-NAME>SatAz9_IPD_SatAz9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatAz9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b8655f0b3c3d306bb202c7ae5b747cf0">
                  <SHORT-NAME>SatCNO10_IPD_SatCNO10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0bda88c971e637d7b752024208eab808">
                  <SHORT-NAME>SatCNO11_IPD_SatCNO11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9874e47253631aabd93fada2e618dc7">
                  <SHORT-NAME>SatCNO12_IPD_SatCNO12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="520e883af64c3b0bacbbaabddb8de04d">
                  <SHORT-NAME>SatCNO13_IPD_SatCNO13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="925182665f3f3313936112e626b14be5">
                  <SHORT-NAME>SatCNO14_IPD_SatCNO14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1669eac416533c6b89ba7f8a75f1d501">
                  <SHORT-NAME>SatCNO15_IPD_SatCNO15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5468b2eb839b337babf3317f2afb8dad">
                  <SHORT-NAME>SatCNO16_IPD_SatCNO16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d54784b99f1e3a28b2efbdb53afc2a11">
                  <SHORT-NAME>SatCNO17_IPD_SatCNO17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5501a7389e23e85a7629e027982f531">
                  <SHORT-NAME>SatCNO18_IPD_SatCNO18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c4ccf03fda94300badad66fd6c44a01d">
                  <SHORT-NAME>SatCNO19_IPD_SatCNO19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5339708a389c303384e8bc0808e20622">
                  <SHORT-NAME>SatCNO1_IPD_SatCNO1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9d1ae7a252f934e1ada5ea0285a16e33">
                  <SHORT-NAME>SatCNO20_IPD_SatCNO20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="390980ffb10c372395744d85a1e0f796">
                  <SHORT-NAME>SatCNO2_IPD_SatCNO2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a55c14cc2f493c18b373aa18a6502681">
                  <SHORT-NAME>SatCNO3_IPD_SatCNO3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59315e41a11a3883bb33b575d0bca063">
                  <SHORT-NAME>SatCNO4_IPD_SatCNO4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dbe82dd84ca135c19162711e5ea15a8d">
                  <SHORT-NAME>SatCNO5_IPD_SatCNO5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="74970d7e224d39f3a1cea618c583fe0f">
                  <SHORT-NAME>SatCNO6_IPD_SatCNO6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="294a4e0097273a589202f05bae58da2c">
                  <SHORT-NAME>SatCNO7_IPD_SatCNO7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e9a2ba435be383a87fb1c9a79c542d5">
                  <SHORT-NAME>SatCNO8_IPD_SatCNO8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8aaba92e6f8a3a789a398d361699ea85">
                  <SHORT-NAME>SatCNO9_IPD_SatCNO9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatCNO9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc1835d5bac636d89ce4b1da2d1d3054">
                  <SHORT-NAME>SatElv10_IPD_SatElv10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="855919ada7593f65af5facb0415e2206">
                  <SHORT-NAME>SatElv11_IPD_SatElv11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f640bb2a6ff3fcd8cab9a96f1c77076">
                  <SHORT-NAME>SatElv12_IPD_SatElv12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3b0d0476e494300dae138042ae0f4dff">
                  <SHORT-NAME>SatElv13_IPD_SatElv13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e6cf173bc2b3213a99ba96f8d151e0b">
                  <SHORT-NAME>SatElv14_IPD_SatElv14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e52c2d474b0032aba698fdc217b64b8f">
                  <SHORT-NAME>SatElv15_IPD_SatElv15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8d7ae8a6eced3d2a854306faa5c21f7c">
                  <SHORT-NAME>SatElv16_IPD_SatElv16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd3ae6e2477b3f9bbe41b478d5b5e5a4">
                  <SHORT-NAME>SatElv17_IPD_SatElv17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="af41e50e92f93f8c9fde45f4099eaca3">
                  <SHORT-NAME>SatElv18_IPD_SatElv18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5716db9c2485373e96f05cff932d3f0c">
                  <SHORT-NAME>SatElv19_IPD_SatElv19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="555d728382043fe1bfc25609be62b724">
                  <SHORT-NAME>SatElv1_IPD_SatElv1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c413e165651332cd93a5044148127d0b">
                  <SHORT-NAME>SatElv20_IPD_SatElv20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d3d725b99d03bf3ba80d89ceeea05ef">
                  <SHORT-NAME>SatElv2_IPD_SatElv2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8ef1712346633216a311988f1ee4319e">
                  <SHORT-NAME>SatElv3_IPD_SatElv3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="783188962af0334089e0e3ea33654ae3">
                  <SHORT-NAME>SatElv4_IPD_SatElv4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="549b6cfec8ce324cbb42df05ac2a097d">
                  <SHORT-NAME>SatElv5_IPD_SatElv5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6183318b04463fc6aa5227b900d1c514">
                  <SHORT-NAME>SatElv6_IPD_SatElv6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="56941fae74cd358ba995b554da9014fc">
                  <SHORT-NAME>SatElv7_IPD_SatElv7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="618bee366da1359681bc081b1d4b19ce">
                  <SHORT-NAME>SatElv8_IPD_SatElv8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="be0008db1c573c6cae7b47f27b924396">
                  <SHORT-NAME>SatElv9_IPD_SatElv9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatElv9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e088c159ebf3b478ed81f206dca1094">
                  <SHORT-NAME>SatID10_IPD_SatID10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3422d6853d843c9a832ce3e23d3c7941">
                  <SHORT-NAME>SatID11_IPD_SatID11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fbac76f03a3034d5a82f6c06a6bec68b">
                  <SHORT-NAME>SatID12_IPD_SatID12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6802efa016ac332e9d7eec1b008a06ae">
                  <SHORT-NAME>SatID13_IPD_SatID13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e821ceebc57733ab86879a7e467dc805">
                  <SHORT-NAME>SatID14_IPD_SatID14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6530afd892a43fe6b1a0cc44f03647ff">
                  <SHORT-NAME>SatID15_IPD_SatID15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5c7f910529b23b0387f0eb32e7c6a6f0">
                  <SHORT-NAME>SatID16_IPD_SatID16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fbdee358889f382485bc73f58253807a">
                  <SHORT-NAME>SatID17_IPD_SatID17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fe242102ed523714bb4851f12692d37c">
                  <SHORT-NAME>SatID18_IPD_SatID18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0fc87e3afb3336acb87b735e68c637a2">
                  <SHORT-NAME>SatID19_IPD_SatID19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57b0f794a7613e4bab7e2ffb0b117377">
                  <SHORT-NAME>SatID1_IPD_SatID1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a66c9e9305a63dc3aa09e5e6eb37f80b">
                  <SHORT-NAME>SatID20_IPD_SatID20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="86e1fbef5700356d948e0ab5424915b6">
                  <SHORT-NAME>SatID2_IPD_SatID2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b2544558aca136afa70f5ca96df76f5a">
                  <SHORT-NAME>SatID3_IPD_SatID3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89630760e631310b8c5e9c7a65d69815">
                  <SHORT-NAME>SatID4_IPD_SatID4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca3c742f314930648ad01fa24eda5d9f">
                  <SHORT-NAME>SatID5_IPD_SatID5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e343cc05820632d78697ad15f86950bd">
                  <SHORT-NAME>SatID6_IPD_SatID6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6781e2cea5f23f93b317803f42065564">
                  <SHORT-NAME>SatID7_IPD_SatID7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f5b8684714e33e2f9bad5ae82c9eeb0f">
                  <SHORT-NAME>SatID8_IPD_SatID8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bc69b96b069b350ea885c18ccf3b81d3">
                  <SHORT-NAME>SatID9_IPD_SatID9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatID9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="441e664e400934858ad2ddd2b88ffbbe">
                  <SHORT-NAME>SatNoInAttitudeRTK_IPD_SatNoInAttitudeRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatNoInAttitudeRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNoInAttitudeRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c79c7b3b6ab737e5bc203878a385a90d">
                  <SHORT-NAME>SatNoInPositionRTK_IPD_SatNoInPositionRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatNoInPositionRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNoInPositionRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="516bdea33711300f9afcc9219fb6c683">
                  <SHORT-NAME>SatNum_IPD_SatNum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SatNum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="102c8047a8db3b8bb2b2b3ef2ba6baa9">
                  <SHORT-NAME>SeatOccptnNum_IPD_SeatOccptnNum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SeatOccptnNum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SeatOccptnNum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8ecfd38d99873c09aafc4ca65cfd587d">
                  <SHORT-NAME>ShftSeqStat_enum_IPD_ShftSeqStat_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ShftSeqStat_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ShftSeqStat_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6340f7a5da793295b897b4a97fea2a45">
                  <SHORT-NAME>SideLghtSts_IPD_SideLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SideLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SideLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="49dd6428ef2430c7a6725ec706fc0b73">
                  <SHORT-NAME>SpdAstCndStsCamr_IPD_SpdAstCndStsCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdAstCndStsCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdAstCndStsCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="916ebb849842393e9f466a36fe64d702">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD_IPD_SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdAstSysTrgtSpd_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdAstSysTrgtSpd_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e444cad28b393693b0cc3d4756bc9723">
                  <SHORT-NAME>SpdLimitManualSts_IPD_SpdLimitManualSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLimitManualSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLimitManualSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a694fa2806293a5a920f1c8183aee05a">
                  <SHORT-NAME>SpdLmtMdMsgReq_IPD_SpdLmtMdMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtMdMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtMdMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc33b517472630ccad117d4ae100ce32">
                  <SHORT-NAME>SpdLmtMdResp_IPD_SpdLmtMdResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtMdResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtMdResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6dd138975dcd35b5a60fb11f695b2f3a">
                  <SHORT-NAME>SpdLmtNav_IPD_SpdLmtNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c94fd4047ef937ba8329ddb5f616b666">
                  <SHORT-NAME>SpdLmtOfstSetNumReq_IPD_SpdLmtOfstSetNumReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetNumReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetNumReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="274b38f541b43fb8985da71fbec207f8">
                  <SHORT-NAME>SpdLmtOfstSetNumResp_IPD_SpdLmtOfstSetNumResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetNumResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetNumResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="628e6fab97753ce283e2996a7249990f">
                  <SHORT-NAME>SpdLmtOfstSetPercReq_IPD_SpdLmtOfstSetPercReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetPercReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetPercReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5ecb77f09172316ba0b6f41aaf983946">
                  <SHORT-NAME>SpdLmtOfstSetPercResp_IPD_SpdLmtOfstSetPercResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetPercResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetPercResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7b0acc96b38936fb8d38800503c233c3">
                  <SHORT-NAME>SpdLmtOfstSetReq_IPD_SpdLmtOfstSetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f323cabde2c63d03b25c8dcf9cb391ac">
                  <SHORT-NAME>SpdLmtOfstSetResp_IPD_SpdLmtOfstSetResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtOfstSetResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84a093c37b0436d89401db21d2df7c14">
                  <SHORT-NAME>SpdLmtPathRngNav_IPD_SpdLmtPathRngNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpdLmtPathRngNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtPathRngNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a1bdab96f9b30e4b84dcb01d9edb13d">
                  <SHORT-NAME>SpedRegulaModSwReq_IPD_SpedRegulaModSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpedRegulaModSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpedRegulaModSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="898c05ad45a53cbbb1569f441a7a9e6e">
                  <SHORT-NAME>SpedRegulaModSwSts_IPD_SpedRegulaModSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SpedRegulaModSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpedRegulaModSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f28b6c66646d368285a887b7e365eb8e">
                  <SHORT-NAME>StrtTypAvail_enum_IPD_StrtTypAvail_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/StrtTypAvail_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/StrtTypAvail_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="54a3604e280d37c6bc3f95a9b8dee765">
                  <SHORT-NAME>SvGroup_IPD_SvGroup</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/SvGroup</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SvGroup</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0b15bfacfed37f2922dcf5c59904b7d">
                  <SHORT-NAME>TASSAMTqSplt_Nm_IPD_TASSAMTqSplt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TASSAMTqSplt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TASSAMTqSplt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9a05c6fc6ae030d791ae2d00d68fda2c">
                  <SHORT-NAME>TASTMTqSplt_Nm_IPD_TASTMTqSplt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TASTMTqSplt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TASTMTqSplt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eeae0a4608533a2790dcc46ce8c97887">
                  <SHORT-NAME>TCM_020ms_PDU18_IPD_TCM_020ms_PDU18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCM_020ms_PDU18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_020ms_PDU18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c2168d8dacf3d958799136ec7480694">
                  <SHORT-NAME>TCM_025ms_Group02_IPD_TCM_025ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCM_025ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_025ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c758cb0c91b03360af1ed64e2b8913ec">
                  <SHORT-NAME>TCM_025ms_PDU20_IPD_TCM_025ms_PDU20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCM_025ms_PDU20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_025ms_PDU20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f070263b00e7388b85055a31080fea2b">
                  <SHORT-NAME>TCM_PTCAN_FrP05_IPD_TCM_PTCAN_FrP05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCM_PTCAN_FrP05</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_PTCAN_FrP05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3c4f1eb1379c3dc4ac950299e20b9f2c">
                  <SHORT-NAME>TCUIntvSAMTq_Nm_IPD_TCUIntvSAMTq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCUIntvSAMTq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUIntvSAMTq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b1e3c45caa9f38ca979f4b8c396d81bb">
                  <SHORT-NAME>TCUIntvTMTq_Nm_IPD_TCUIntvTMTq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCUIntvTMTq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUIntvTMTq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="093debb1919232b4ae07526c2fec64ec">
                  <SHORT-NAME>TCUOpSt_enum_IPD_TCUOpSt_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TCUOpSt_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUOpSt_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dcae61f482e73b98a05d376fac2de70d">
                  <SHORT-NAME>TDMAvlbly_IPD_TDMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TDMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TDMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d507de6dfa9b372fa657e6965ef59a45">
                  <SHORT-NAME>TDM_200ms_Group01_IPD_TDM_200ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TDM_200ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TDM_200ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0f94d5edc8b53e428b791e597c8abcf1">
                  <SHORT-NAME>TJAICAMsgReq_IPD_TJAICAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TJAICAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TJAICAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="12ccc87568b13be0a8ef38c82a65955b">
                  <SHORT-NAME>TLRMdSwDspCmd_IPD_TLRMdSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TLRMdSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMdSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4009351c38ab3bf2a90dea9660478761">
                  <SHORT-NAME>TLRMdSwReq_IPD_TLRMdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TLRMdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="08ebc0f0a1ac394abd8192526c69df9e">
                  <SHORT-NAME>TLRMsgReq_IPD_TLRMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TLRMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="491dc1316f263611ad988e11f278f7c9">
                  <SHORT-NAME>TLRSysSts_IPD_TLRSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TLRSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de3f145c85b43635a6e59cf53902d94e">
                  <SHORT-NAME>TLRWarning_IPD_TLRWarning</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TLRWarning</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRWarning</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84b053f508733b40bfd1d44e2229af83">
                  <SHORT-NAME>TPMSBtmNosRSSI_IPD_TPMSBtmNosRSSI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSBtmNosRSSI</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSBtmNosRSSI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d55203372cfe3a3aa27ba90a0aed7ba1">
                  <SHORT-NAME>TPMSSnsrIDLoctn_IPD_TPMSSnsrIDLoctn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSSnsrIDLoctn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrIDLoctn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="432e2452084b38c9bc0c50ee994dfa22">
                  <SHORT-NAME>TPMSSnsrID_IPD_TPMSSnsrID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSSnsrID</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84796c15e056324392a7647df7e98558">
                  <SHORT-NAME>TPMSSnsrRSSI_IPD_TPMSSnsrRSSI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSSnsrRSSI</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRSSI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ac9be2c4f77535088173e2dbdd6ba4ae">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn_IPD_TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSSnsrRdoFrqcCtrLoctn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRdoFrqcCtrLoctn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f9c3487354bc309fb343b540b91674f8">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr_IPD_TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSSnsrRdoFrqcCtr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRdoFrqcCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5f6f497ff9e433388531a8bd81910204">
                  <SHORT-NAME>TPMSWntrMdA_IPD_TPMSWntrMdA</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TPMSWntrMdA</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSWntrMdA</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e70ae923d8f235dcbf738af332c4dc92">
                  <SHORT-NAME>TQRTMTqReq_N_IPD_TQRTMTqReq_N</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TQRTMTqReq_N</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TQRTMTqReq_N</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0bfe13ca08537dc93eabbc154adf7be">
                  <SHORT-NAME>TRCEMTqReq_Nm_IPD_TRCEMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TRCEMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TRCEMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6360ae6d89353623af77f598c4dae31f">
                  <SHORT-NAME>TRCTqDmdSTC_Nm_IPD_TRCTqDmdSTC_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TRCTqDmdSTC_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TRCTqDmdSTC_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="66ded1991d593f03b3dc873c73924bd4">
                  <SHORT-NAME>TSRSts_IPD_TSRSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TSRSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="27bf12b10db63003b382bafd9b6293d6">
                  <SHORT-NAME>TSRSwReqResp_IPD_TSRSwReqResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TSRSwReqResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSwReqResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c2ed3c2ddc5a3714bd6eee0ee7b90fb9">
                  <SHORT-NAME>TSRSwReq_IPD_TSRSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TSRSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e53b9e6450533101bcd031678f5c9302">
                  <SHORT-NAME>TSRTrgtBanSign_IPD_TSRTrgtBanSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TSRTrgtBanSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRTrgtBanSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5f81feba3364330aba4c52dd38e3e70f">
                  <SHORT-NAME>TSRTrgtWarnSign_IPD_TSRTrgtWarnSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TSRTrgtWarnSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRTrgtWarnSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cec32574380a3f54a55e5b85cd180766">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm_IPD_TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TZXEMMaxTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TZXEMMaxTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c583186b32e3bb8b7551577d629eb71">
                  <SHORT-NAME>TZXEMTqReq_Nm_IPD_TZXEMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TZXEMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TZXEMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b714f91a294350a8c0c60c80b4e3773">
                  <SHORT-NAME>TemSnsrHdwrFltPrst_IPD_TemSnsrHdwrFltPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TemSnsrHdwrFltPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TemSnsrHdwrFltPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ba9cc50573935059841d00f0cf35a90">
                  <SHORT-NAME>TgtParkingFavorite_IPD_TgtParkingFavorite</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TgtParkingFavorite</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TgtParkingFavorite</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aee10fc1151633c9b50ca286c8bf83ff">
                  <SHORT-NAME>ToEPSMsgChlg_IPD_ToEPSMsgChlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ToEPSMsgChlg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ToEPSMsgChlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e3eadb2cb233218ab697d743a475380">
                  <SHORT-NAME>TqCtrlStat_enum_IPD_TqCtrlStat_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TqCtrlStat_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TqCtrlStat_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="423be3206fef3cff9c225792b923f52b">
                  <SHORT-NAME>TrdtnKeyBtnSts_IPD_TrdtnKeyBtnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrdtnKeyBtnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnKeyBtnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="08dbf88dd54d38f58986d1fc017ecb7b">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts_IPD_TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrdtnSmrtKyFindCarSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyFindCarSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9ddff555c5c03d14921f78f6f0988211">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts_IPD_TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrdtnSmrtKyLckSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyLckSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e506d039a50632d5baf8b868fd43b9aa">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts_IPD_TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrdtnSmrtKyLdspcSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyLdspcSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e9692db3e4438b6a0447e23ac4ba273">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts_IPD_TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrdtnSmrtKyUnlckSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyUnlckSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="019076a8b826329fa69012e2b97e73f3">
                  <SHORT-NAME>TrfGreenLghtActn_IPD_TrfGreenLghtActn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfGreenLghtActn</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfGreenLghtActn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e49bd03b43f43608bbab4a15898277a3">
                  <SHORT-NAME>TrfcForbidDist_IPD_TrfcForbidDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcForbidDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcForbidDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4d27b95e9fa739959c300cc458449e85">
                  <SHORT-NAME>TrfcInfoSignDist_IPD_TrfcInfoSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcInfoSignDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcInfoSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="477ec6f9f16f3266a0b7acc89f6288e7">
                  <SHORT-NAME>TrfcJamRngNav_IPD_TrfcJamRngNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcJamRngNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcJamRngNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4713a363ee9835bba3b9b1a184ab4657">
                  <SHORT-NAME>TrfcLghtFuctionSwReq_IPD_TrfcLghtFuctionSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcLghtFuctionSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtFuctionSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c8184439400d3d9596e546c0a8e6278a">
                  <SHORT-NAME>TrfcLghtFuctionSwSts_IPD_TrfcLghtFuctionSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcLghtFuctionSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtFuctionSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="79e3aedd265a314bb978baaa4034172d">
                  <SHORT-NAME>TrfcLghtStSp_IPD_TrfcLghtStSp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcLghtStSp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcLghtStSp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="906eb8e16a863be89bd6a5f6ac0ee1ca">
                  <SHORT-NAME>TrfcMrgdForbidDist_IPD_TrfcMrgdForbidDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdForbidDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdForbidDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a527b6694db93ed5b94c3721c64d9382">
                  <SHORT-NAME>TrfcMrgdForbidSign_IPD_TrfcMrgdForbidSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdForbidSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdForbidSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="65a998ef98a53f37aba16a4c17a5ca0f">
                  <SHORT-NAME>TrfcMrgdInfoSignDist_IPD_TrfcMrgdInfoSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdInfoSignDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdInfoSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bed4fcd19bf8307ab00ef49c7e292385">
                  <SHORT-NAME>TrfcMrgdInfoSign_IPD_TrfcMrgdInfoSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdInfoSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdInfoSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="909134078d8334bab9b92f1ba06bcbfa">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist_IPD_TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdWrnngSignDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdWrnngSignDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="32e574240dea35e682af0019c99b4b73">
                  <SHORT-NAME>TrfcMrgdWrnngSign_IPD_TrfcMrgdWrnngSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrfcMrgdWrnngSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcMrgdWrnngSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db11347503e232a0b0d8a2d36e717397">
                  <SHORT-NAME>TrgtCndSpdReqCamr_IPD_TrgtCndSpdReqCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrgtCndSpdReqCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrgtCndSpdReqCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4a06bb1125933559829e0e6894103bab">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD_IPD_TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TrgtSpdSrcSts_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrgtSpdSrcSts_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="03ca74d8c33f3ee2a381c25f5c7e5b4e">
                  <SHORT-NAME>TripCntResetReq_IPD_TripCntResetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TripCntResetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TripCntResetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="88262645989732b983a953a035ba5ac6">
                  <SHORT-NAME>TripCnt_IPD_TripCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/TripCnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TripCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6011f5e6156e37a6acb7fef01262d5ce">
                  <SHORT-NAME>VDCSlipCtrlSts_enum_IPD_VDCSlipCtrlSts_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VDCSlipCtrlSts_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VDCSlipCtrlSts_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="03691ba027ad38efbb06f2d4703e4e3c">
                  <SHORT-NAME>VehTiPblshDay_IPD_VehTiPblshDay</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshDay</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshDay</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b183309ef6b431cfac92c6899bad4b54">
                  <SHORT-NAME>VehTiPblshHr_IPD_VehTiPblshHr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshHr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshHr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b6ad1e44d218370f946eeb0e3731edf9">
                  <SHORT-NAME>VehTiPblshMins_IPD_VehTiPblshMins</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshMins</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshMins</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="58a118d566a337c197d2660cf6d6da1c">
                  <SHORT-NAME>VehTiPblshMth_IPD_VehTiPblshMth</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshMth</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshMth</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e84aed61212f3dbc9a7548d6c8cf4ccd">
                  <SHORT-NAME>VehTiPblshSec_IPD_VehTiPblshSec</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshSec</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshSec</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a05e587db63397d851dc39ac4298dbc">
                  <SHORT-NAME>VehTiPblshYear_IPD_VehTiPblshYear</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/VehTiPblshYear</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/VehTiPblshYear</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b7512c89954c3962b114fdf0ef94beb8">
                  <SHORT-NAME>Veldownsigma_IPD_Veldownsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Veldownsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Veldownsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c753e9c946bb321b9d57e12810b18616">
                  <SHORT-NAME>Veleastsigma_IPD_Veleastsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Veleastsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Veleastsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d0d5cebb664639789ffcb2b0f369446a">
                  <SHORT-NAME>Velnorthsigma_IPD_Velnorthsigma</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Velnorthsigma</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Velnorthsigma</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="927b614bc3153c62b73a5aee5aef8400">
                  <SHORT-NAME>WhlRghRoadV_IPD_WhlRghRoadV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/WhlRghRoadV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/WhlRghRoadV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="491dfa15e5e03d71ac8d9f0c3b2f232f">
                  <SHORT-NAME>WhlRghRoad_IPD_WhlRghRoad</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/WhlRghRoad</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/WhlRghRoad</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
              </CONNECTORS>
            </COMPOSITION-SW-COMPONENT-TYPE>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="a755ee0b4dae3e11972420dec9eeb7e1">
          <SHORT-NAME>Interfaces</SHORT-NAME>
          <ELEMENTS>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104cfaXOa505a3f19f25843c4b104cf900">
              <SHORT-NAME>ACCConfmSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d05XOa505a3f19f25843c4b104d0400">
                  <SHORT-NAME>ACCConfmSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCConfmSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f00XOa505a3f19f25843c4b107eff00">
              <SHORT-NAME>ACCConfmSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f0bXOa505a3f19f25843c4b107f0a00">
                  <SHORT-NAME>ACCConfmSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCConfmSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d11XOa505a3f19f25843c4b104d1000">
              <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d1cXOa505a3f19f25843c4b104d1b00">
                  <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCCurveSpdSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f17XOa505a3f19f25843c4b107f1600">
              <SHORT-NAME>ACCCurveSpdSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f22XOa505a3f19f25843c4b107f2100">
                  <SHORT-NAME>ACCCurveSpdSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCCurveSpdSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d28XOa505a3f19f25843c4b104d2700">
              <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d33XOa505a3f19f25843c4b104d3200">
                  <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d3fXOa505a3f19f25843c4b104d3e00">
              <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d4aXOa505a3f19f25843c4b104d4900">
                  <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1Id</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d56XOa505a3f19f25843c4b104d5500">
              <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d61XOa505a3f19f25843c4b104d6000">
                  <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1LatRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d6dXOa505a3f19f25843c4b104d6c00">
              <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d78XOa505a3f19f25843c4b104d7700">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1LongtRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d84XOa505a3f19f25843c4b104d8300">
              <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104d8fXOa505a3f19f25843c4b104d8e00">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1LongtRltvSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104d9bXOa505a3f19f25843c4b104d9a00">
              <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104da6XOa505a3f19f25843c4b104da500">
                  <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1Risk</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104db2XOa505a3f19f25843c4b104db100">
              <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104dbdXOa505a3f19f25843c4b104dbc00">
                  <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1SyncCtr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104dc9XOa505a3f19f25843c4b104dc800">
              <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104dd4XOa505a3f19f25843c4b104dd300">
                  <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj1Typ</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104de0XOa505a3f19f25843c4b104ddf00">
              <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104debXOa505a3f19f25843c4b104dea00">
                  <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104df7XOa505a3f19f25843c4b104df600">
              <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e02XOa505a3f19f25843c4b104e0100">
                  <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2Id</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e0eXOa505a3f19f25843c4b104e0d00">
              <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e19XOa505a3f19f25843c4b104e1800">
                  <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2LatRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e25XOa505a3f19f25843c4b104e2400">
              <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e30XOa505a3f19f25843c4b104e2f00">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2LongtRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e3cXOa505a3f19f25843c4b104e3b00">
              <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e47XOa505a3f19f25843c4b104e4600">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2LongtRltvSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e53XOa505a3f19f25843c4b104e5200">
              <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e5eXOa505a3f19f25843c4b104e5d00">
                  <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2Risk</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e6aXOa505a3f19f25843c4b104e6900">
              <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e75XOa505a3f19f25843c4b104e7400">
                  <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2SyncCtr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e81XOa505a3f19f25843c4b104e8000">
              <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104e8cXOa505a3f19f25843c4b104e8b00">
                  <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj2Typ</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104e98XOa505a3f19f25843c4b104e9700">
              <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104ea3XOa505a3f19f25843c4b104ea200">
                  <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3ExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104eafXOa505a3f19f25843c4b104eae00">
              <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104ebaXOa505a3f19f25843c4b104eb900">
                  <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3Id</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104ec6XOa505a3f19f25843c4b104ec500">
              <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104ed1XOa505a3f19f25843c4b104ed000">
                  <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3LatRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104eddXOa505a3f19f25843c4b104edc00">
              <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104ee8XOa505a3f19f25843c4b104ee700">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3LongtRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104ef4XOa505a3f19f25843c4b104ef300">
              <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104effXOa505a3f19f25843c4b104efe00">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3LongtRltvSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f0bXOa505a3f19f25843c4b104f0a00">
              <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f16XOa505a3f19f25843c4b104f1500">
                  <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3Risk</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f22XOa505a3f19f25843c4b104f2100">
              <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f2dXOa505a3f19f25843c4b104f2c00">
                  <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3SyncCtr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f39XOa505a3f19f25843c4b104f3800">
              <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f44XOa505a3f19f25843c4b104f4300">
                  <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObj3Typ</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f50XOa505a3f19f25843c4b104f4f00">
              <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f5bXOa505a3f19f25843c4b104f5a00">
                  <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjExistPrblty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121ac6XOa505a3f19f25843c4b121ac500">
              <SHORT-NAME>ACCDetObjHdngAng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121ad1XOa505a3f19f25843c4b121ad000">
                  <SHORT-NAME>ACCDetObjHdngAng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjHdngAng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f67XOa505a3f19f25843c4b104f6600">
              <SHORT-NAME>ACCDetObjId</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f72XOa505a3f19f25843c4b104f7100">
                  <SHORT-NAME>ACCDetObjId</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjId</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f7eXOa505a3f19f25843c4b104f7d00">
              <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104f89XOa505a3f19f25843c4b104f8800">
                  <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjLatRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104f95XOa505a3f19f25843c4b104f9400">
              <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104fa0XOa505a3f19f25843c4b104f9f00">
                  <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjLongtRltvDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104facXOa505a3f19f25843c4b104fab00">
              <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104fb7XOa505a3f19f25843c4b104fb600">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjLongtRltvSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104fc3XOa505a3f19f25843c4b104fc200">
              <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104fceXOa505a3f19f25843c4b104fcd00">
                  <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjRisk</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104fdaXOa505a3f19f25843c4b104fd900">
              <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104fe5XOa505a3f19f25843c4b104fe400">
                  <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjSyncCtr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b104ff1XOa505a3f19f25843c4b104ff000">
              <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b104ffcXOa505a3f19f25843c4b104ffb00">
                  <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDetObjTyp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f3a1b4132298e9XNa505a3f19f3a1b4132298e300">
              <SHORT-NAME>ACCDrvrTkovReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f3a1b4132298f6XNa505a3f19f3a1b4132298f000">
                  <SHORT-NAME>ACCDrvrTkovReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCDrvrTkovReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121aafXOa505a3f19f25843c4b121aae00">
              <SHORT-NAME>ACCObjDet</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121abaXOa505a3f19f25843c4b121ab900">
                  <SHORT-NAME>ACCObjDet</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCObjDet</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105008XOa505a3f19f25843c4b10500700">
              <SHORT-NAME>ACCSpdLimtSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105013XOa505a3f19f25843c4b10501200">
                  <SHORT-NAME>ACCSpdLimtSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCSpdLimtSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f2eXOa505a3f19f25843c4b107f2d00">
              <SHORT-NAME>ACCSpdLimtSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f39XOa505a3f19f25843c4b107f3800">
                  <SHORT-NAME>ACCSpdLimtSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCSpdLimtSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10501fXOa505a3f19f25843c4b10501e00">
              <SHORT-NAME>ACCStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10502aXOa505a3f19f25843c4b10502900">
                  <SHORT-NAME>ACCStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105036XOa505a3f19f25843c4b10503500">
              <SHORT-NAME>ACCStsSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105041XOa505a3f19f25843c4b10504000">
                  <SHORT-NAME>ACCStsSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCStsSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f45XOa505a3f19f25843c4b107f4400">
              <SHORT-NAME>ACCStsSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f50XOa505a3f19f25843c4b107f4f00">
                  <SHORT-NAME>ACCStsSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCStsSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f5cXOa505a3f19f25843c4b107f5b00">
              <SHORT-NAME>ACCTJAMdSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f67XOa505a3f19f25843c4b107f6600">
                  <SHORT-NAME>ACCTJAMdSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACCTJAMdSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107f8aXOa505a3f19f25843c4b107f8900">
              <SHORT-NAME>ACSFCatgrAStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b107f95XOa505a3f19f25843c4b107f9400">
                  <SHORT-NAME>ACSFCatgrAStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrAStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10504dXOa505a3f19f25843c4b10504c00">
              <SHORT-NAME>ACSFCatgrB1StsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105058XOa505a3f19f25843c4b10505700">
                  <SHORT-NAME>ACSFCatgrB1StsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrB1StsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108d8eXOa505a3f19f25843c4b108d8d00">
              <SHORT-NAME>ACSFCatgrB2StsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108d99XOa505a3f19f25843c4b108d9800">
                  <SHORT-NAME>ACSFCatgrB2StsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrB2StsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105064XOa505a3f19f25843c4b10506300">
              <SHORT-NAME>ACSFCatgrCStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10506fXOa505a3f19f25843c4b10506e00">
                  <SHORT-NAME>ACSFCatgrCStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrCStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10507bXOa505a3f19f25843c4b10507a00">
              <SHORT-NAME>ACSFCatgrDStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105086XOa505a3f19f25843c4b10508500">
                  <SHORT-NAME>ACSFCatgrDStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrDStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105092XOa505a3f19f25843c4b10509100">
              <SHORT-NAME>ACSFCatgrEStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10509dXOa505a3f19f25843c4b10509c00">
                  <SHORT-NAME>ACSFCatgrEStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ACSFCatgrEStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10802bXOa505a3f19f25843c4b10802a00">
              <SHORT-NAME>ADAudioSWReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108036XOa505a3f19f25843c4b10803500">
                  <SHORT-NAME>ADAudioSWReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ADAudioSWReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1050a9XOa505a3f19f25843c4b1050a800">
              <SHORT-NAME>ADAudioSWSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1050b4XOa505a3f19f25843c4b1050b300">
                  <SHORT-NAME>ADAudioSWSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ADAudioSWSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1232f1XOa505a3f19f25843c4b1232f000">
              <SHORT-NAME>ADS_ISAMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1232fcXOa505a3f19f25843c4b1232fb00">
                  <SHORT-NAME>ADS_ISAMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ADS_ISAMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b123309XOa505a3f19f25843c4b12330800">
              <SHORT-NAME>ADS_ISASysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b123314XOa505a3f19f25843c4b12331300">
                  <SHORT-NAME>ADS_ISASysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ADS_ISASysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b123321XOa505a3f19f25843c4b12332000">
              <SHORT-NAME>ADS_ISASysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b12332cXOa505a3f19f25843c4b12332b00">
                  <SHORT-NAME>ADS_ISASysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ADS_ISASysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1050c0XOa505a3f19f25843c4b1050bf00">
              <SHORT-NAME>AEBDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1050cbXOa505a3f19f25843c4b1050ca00">
                  <SHORT-NAME>AEBDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AEBDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1050d7XOa505a3f19f25843c4b1050d600">
              <SHORT-NAME>AEBMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1050e2XOa505a3f19f25843c4b1050e100">
                  <SHORT-NAME>AEBMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AEBMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1050eeXOa505a3f19f25843c4b1050ed00">
              <SHORT-NAME>AEBStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1050f9XOa505a3f19f25843c4b1050f800">
                  <SHORT-NAME>AEBStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AEBStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108042XOa505a3f19f25843c4b10804100">
              <SHORT-NAME>AEBSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10804dXOa505a3f19f25843c4b10804c00">
                  <SHORT-NAME>AEBSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AEBSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc55XOa505a3f19f25843c4b10fc5400">
              <SHORT-NAME>AIParkngDsp</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc60XOa505a3f19f25843c4b10fc5f00">
                  <SHORT-NAME>AIParkngDsp</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngDsp</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c560XOa505a3f19f25843c4b11c55f00">
              <SHORT-NAME>AIParkngEPAMdsts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c56bXOa505a3f19f25843c4b11c56a00">
                  <SHORT-NAME>AIParkngEPAMdsts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngEPAMdsts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119ba4XOa505a3f19f25843c4b119ba300">
              <SHORT-NAME>AIParkngEPAMdsw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119bafXOa505a3f19f25843c4b119bae00">
                  <SHORT-NAME>AIParkngEPAMdsw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngEPAMdsw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e3ceXOa505a3f19f25843c4b10e3cd00">
              <SHORT-NAME>AIParkngReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e3d9XOa505a3f19f25843c4b10e3d800">
                  <SHORT-NAME>AIParkngReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10feabXOa505a3f19f25843c4b10feaa00">
              <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10feb6XOa505a3f19f25843c4b10feb500">
                  <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngReqICB</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e3b7XOa505a3f19f25843c4b10e3b600">
              <SHORT-NAME>AIParkngReq_ZXD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e3c2XOa505a3f19f25843c4b10e3c100">
                  <SHORT-NAME>AIParkngReq_ZXD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngReq_ZXD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c5bcXOa505a3f19f25843c4b11c5bb00">
              <SHORT-NAME>AIParkngRespICB</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c5c7XOa505a3f19f25843c4b11c5c600">
                  <SHORT-NAME>AIParkngRespICB</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngRespICB</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa23XOa505a3f19f25843c4b11fa2200">
              <SHORT-NAME>AIParkngSSPLotSw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fa2eXOa505a3f19f25843c4b11fa2d00">
                  <SHORT-NAME>AIParkngSSPLotSw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngSSPLotSw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11fa3aXOa505a3f19f25843c4b11fa3900">
              <SHORT-NAME>AIParkngSSPLotSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11fa45XOa505a3f19f25843c4b11fa4400">
                  <SHORT-NAME>AIParkngSSPLotSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngSSPLotSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef65XOa505a3f19f25843c4b10ef6400">
              <SHORT-NAME>AIParkngSpcID</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef70XOa505a3f19f25843c4b10ef6f00">
                  <SHORT-NAME>AIParkngSpcID</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngSpcID</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f176XOa505a3f19f25843c4b10f17500">
              <SHORT-NAME>AIParkngSpdsw</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f181XOa505a3f19f25843c4b10f18000">
                  <SHORT-NAME>AIParkngSpdsw</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngSpdsw</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc3eXOa505a3f19f25843c4b10fc3d00">
              <SHORT-NAME>AIParkngSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc49XOa505a3f19f25843c4b10fc4800">
                  <SHORT-NAME>AIParkngSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIParkngSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb13XOa505a3f19f25843c4b10fb1200">
              <SHORT-NAME>AIPilotIntervQuit</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb1eXOa505a3f19f25843c4b10fb1d00">
                  <SHORT-NAME>AIPilotIntervQuit</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AIPilotIntervQuit</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef4eXOa505a3f19f25843c4b10ef4d00">
              <SHORT-NAME>APAOneKeyParkSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef59XOa505a3f19f25843c4b10ef5800">
                  <SHORT-NAME>APAOneKeyParkSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APAOneKeyParkSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc10XOa505a3f19f25843c4b10fc0f00">
              <SHORT-NAME>APAParkInOffsetType</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc1bXOa505a3f19f25843c4b10fc1a00">
                  <SHORT-NAME>APAParkInOffsetType</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APAParkInOffsetType</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f11aXOa505a3f19f25843c4b10f11900">
              <SHORT-NAME>APAParkInOffsetTypeReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f125XOa505a3f19f25843c4b10f12400">
                  <SHORT-NAME>APAParkInOffsetTypeReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APAParkInOffsetTypeReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc27XOa505a3f19f25843c4b10fc2600">
              <SHORT-NAME>APARemShifGear</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc32XOa505a3f19f25843c4b10fc3100">
                  <SHORT-NAME>APARemShifGear</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APARemShifGear</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fb41XOa505a3f19f25843c4b10fb4000">
              <SHORT-NAME>APASW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb4cXOa505a3f19f25843c4b10fb4b00">
                  <SHORT-NAME>APASW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APASW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f0ecXOa505a3f19f25843c4b10f0eb00">
              <SHORT-NAME>APASWReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f0f7XOa505a3f19f25843c4b10f0f600">
                  <SHORT-NAME>APASWReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APASWReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f3a1b413229a38XNa505a3f19f3a1b413229a3200">
              <SHORT-NAME>APASpdMdSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f3a1b413229a45XNa505a3f19f3a1b413229a3f00">
                  <SHORT-NAME>APASpdMdSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/APASpdMdSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10efaaXOa505a3f19f25843c4b10efa900">
              <SHORT-NAME>AVMDspReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10efb5XOa505a3f19f25843c4b10efb400">
                  <SHORT-NAME>AVMDspReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AVMDspReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10efc1XOa505a3f19f25843c4b10efc000">
              <SHORT-NAME>AVMSt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10efccXOa505a3f19f25843c4b10efcb00">
                  <SHORT-NAME>AVMSt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AVMSt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b12261aXOa505a3f19f25843c4b12261900">
              <SHORT-NAME>AVPMapRutMgIDtReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b122625XOa505a3f19f25843c4b12262400">
                  <SHORT-NAME>AVPMapRutMgIDtReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AVPMapRutMgIDtReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee68XOa505a3f19f25843c4b10ee6700">
              <SHORT-NAME>AutoLaneChngSetReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee73XOa505a3f19f25843c4b10ee7200">
                  <SHORT-NAME>AutoLaneChngSetReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AutoLaneChngSetReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee51XOa505a3f19f25843c4b10ee5000">
              <SHORT-NAME>AutoLaneChngSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee5cXOa505a3f19f25843c4b10ee5b00">
                  <SHORT-NAME>AutoLaneChngSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AutoLaneChngSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee7fXOa505a3f19f25843c4b10ee7e00">
              <SHORT-NAME>AutoLaneChngVcCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee8aXOa505a3f19f25843c4b10ee8900">
                  <SHORT-NAME>AutoLaneChngVcCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AutoLaneChngVcCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108f5aXOa505a3f19f25843c4b108f5900">
              <SHORT-NAME>AutoMainBeamLghtOn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108f65XOa505a3f19f25843c4b108f6400">
                  <SHORT-NAME>AutoMainBeamLghtOn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AutoMainBeamLghtOn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105105XOa505a3f19f25843c4b10510400">
              <SHORT-NAME>AutoMainBeamLghtReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105110XOa505a3f19f25843c4b10510f00">
                  <SHORT-NAME>AutoMainBeamLghtReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/AutoMainBeamLghtReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10edc7XOa505a3f19f25843c4b10edc600">
              <SHORT-NAME>BSDSelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10edd2XOa505a3f19f25843c4b10edd100">
                  <SHORT-NAME>BSDSelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/BSDSelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10baceXOa505a3f19f25843c4b10bacd00">
              <SHORT-NAME>BaseLineLen</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bad9XOa505a3f19f25843c4b10bad800">
                  <SHORT-NAME>BaseLineLen</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/BaseLineLen</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bae5XOa505a3f19f25843c4b10bae400">
              <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10baf0XOa505a3f19f25843c4b10baef00">
                  <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/CANprotocolinternalversion</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c549XOa505a3f19f25843c4b11c54800">
              <SHORT-NAME>CCSpdVcCmdCnfm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c554XOa505a3f19f25843c4b11c55300">
                  <SHORT-NAME>CCSpdVcCmdCnfm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/CCSpdVcCmdCnfm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10511cXOa505a3f19f25843c4b10511b00">
              <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105127XOa505a3f19f25843c4b10512600">
                  <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/CCSpdlVcCmdSwReqDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101e85XOa505a3f19f25843c4b101e8400">
              <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b101e90XOa505a3f19f25843c4b101e8f00">
                  <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/CCU_100ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4ba371bfXOa505a3f19f25843c4ba371b900">
              <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4ba371ccXOa505a3f19f25843c4ba371c600">
                  <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/CCU_100ms_Group07</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10220cXOa505a3f19f25843c4b10220b00">
              <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102217XOa505a3f19f25843c4b10221600">
                  <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/CCU_100ms_Group11</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105133XOa505a3f19f25843c4b10513200">
              <SHORT-NAME>CSFStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10513eXOa505a3f19f25843c4b10513d00">
                  <SHORT-NAME>CSFStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/CSFStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110f20XOa505a3f19f25843c4b110f1f00">
              <SHORT-NAME>ChrgPwrReq_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110f2bXOa505a3f19f25843c4b110f2a00">
                  <SHORT-NAME>ChrgPwrReq_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ChrgPwrReq_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110f37XOa505a3f19f25843c4b110f3600">
              <SHORT-NAME>ChrgReq_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110f42XOa505a3f19f25843c4b110f4100">
                  <SHORT-NAME>ChrgReq_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ChrgReq_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119b8dXOa505a3f19f25843c4b119b8c00">
              <SHORT-NAME>ClstrDspdVehSpd_mph</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119b98XOa505a3f19f25843c4b119b9700">
                  <SHORT-NAME>ClstrDspdVehSpd_mph</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ClstrDspdVehSpd_mph</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10e133XOa505a3f19f25843c4b10e13200">
              <SHORT-NAME>ComKeyEnbReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10e13eXOa505a3f19f25843c4b10e13d00">
                  <SHORT-NAME>ComKeyEnbReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ComKeyEnbReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119bd2XOa505a3f19f25843c4b119bd100">
              <SHORT-NAME>D2DPriETClanSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119bddXOa505a3f19f25843c4b119bdc00">
                  <SHORT-NAME>D2DPriETClanSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/D2DPriETClanSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c5eaXOa505a3f19f25843c4b11c5e900">
              <SHORT-NAME>D2DPriETClanSwReqResps</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c5f5XOa505a3f19f25843c4b11c5f400">
                  <SHORT-NAME>D2DPriETClanSwReqResps</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/D2DPriETClanSwReqResps</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b119bbbXOa505a3f19f25843c4b119bba00">
              <SHORT-NAME>D2DSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b119bc6XOa505a3f19f25843c4b119bc500">
                  <SHORT-NAME>D2DSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/D2DSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c5d3XOa505a3f19f25843c4b11c5d200">
              <SHORT-NAME>D2DSwReqResps</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c5deXOa505a3f19f25843c4b11c5dd00">
                  <SHORT-NAME>D2DSwReqResps</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/D2DSwReqResps</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c601XOa505a3f19f25843c4b11c60000">
              <SHORT-NAME>D2DSysSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c60cXOa505a3f19f25843c4b11c60b00">
                  <SHORT-NAME>D2DSysSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/D2DSysSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110f4eXOa505a3f19f25843c4b110f4d00">
              <SHORT-NAME>DFC_Current_DisplyBuffer_0</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110f59XOa505a3f19f25843c4b110f5800">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DFC_Current_DisplyBuffer_0</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110f65XOa505a3f19f25843c4b110f6400">
              <SHORT-NAME>DFC_Current_DisplyBuffer_1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110f70XOa505a3f19f25843c4b110f6f00">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DFC_Current_DisplyBuffer_1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110f7cXOa505a3f19f25843c4b110f7b00">
              <SHORT-NAME>DFC_Current_DisplyBuffer_2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110f87XOa505a3f19f25843c4b110f8600">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DFC_Current_DisplyBuffer_2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b122a06XOa505a3f19f25843c4b122a0500">
              <SHORT-NAME>DMSCameraFps_IMM</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b122a11XOa505a3f19f25843c4b122a1000">
                  <SHORT-NAME>DMSCameraFps_IMM</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DMSCameraFps_IMM</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee0cXOa505a3f19f25843c4b10ee0b00">
              <SHORT-NAME>DOWSelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee17XOa505a3f19f25843c4b10ee1600">
                  <SHORT-NAME>DOWSelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DOWSelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10a09aXOa505a3f19f25843c4b10a09900">
              <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10a0a5XOa505a3f19f25843c4b10a0a400">
                  <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DTCInfomationIPD</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fc83XOa505a3f19f25843c4b10fc8200">
              <SHORT-NAME>DetourMsgReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fc8eXOa505a3f19f25843c4b10fc8d00">
                  <SHORT-NAME>DetourMsgReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DetourMsgReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b106ddeXOa505a3f19f25843c4b106ddd00">
              <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b106de9XOa505a3f19f25843c4b106de800">
                  <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DfstOnDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bafcXOa505a3f19f25843c4b10bafb00">
              <SHORT-NAME>DiffAgeInfo</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb07XOa505a3f19f25843c4b10bb0600">
                  <SHORT-NAME>DiffAgeInfo</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DiffAgeInfo</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bb13XOa505a3f19f25843c4b10bb1200">
              <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb1eXOa505a3f19f25843c4b10bb1d00">
                  <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DiffDataLinkBroken</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ad2eXOa505a3f19f25843c4b10ad2d00">
              <SHORT-NAME>DircnIndLghtMdSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ad39XOa505a3f19f25843c4b10ad3800">
                  <SHORT-NAME>DircnIndLghtMdSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DircnIndLghtMdSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105b17XOa505a3f19f25843c4b105b1600">
              <SHORT-NAME>DircnIndLghtSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105b22XOa505a3f19f25843c4b105b2100">
                  <SHORT-NAME>DircnIndLghtSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DircnIndLghtSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1230f9XOa505a3f19f25843c4b1230f800">
              <SHORT-NAME>DistSinceTrgtCamr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b123104XOa505a3f19f25843c4b12310300">
                  <SHORT-NAME>DistSinceTrgtCamr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DistSinceTrgtCamr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11181cXOa505a3f19f25843c4b11181b00">
              <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111827XOa505a3f19f25843c4b11182600">
                  <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DistToTrfcJamNav</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bb2aXOa505a3f19f25843c4b10bb2900">
              <SHORT-NAME>DownVelocityRTK</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb35XOa505a3f19f25843c4b10bb3400">
                  <SHORT-NAME>DownVelocityRTK</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DownVelocityRTK</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110faaXOa505a3f19f25843c4b110fa900">
              <SHORT-NAME>DrvTqReqWhlFilt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110fb5XOa505a3f19f25843c4b110fb400">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DrvTqReqWhlFilt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110fc1XOa505a3f19f25843c4b110fc000">
              <SHORT-NAME>DrvTqReqWhlRawCap_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110fccXOa505a3f19f25843c4b110fcb00">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DrvTqReqWhlRawCap_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110fd8XOa505a3f19f25843c4b110fd700">
              <SHORT-NAME>DrvTqReqWhlRaw_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110fe3XOa505a3f19f25843c4b110fe200">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DrvTqReqWhlRaw_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ed82XOa505a3f19f25843c4b10ed8100">
              <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ed8dXOa505a3f19f25843c4b10ed8c00">
                  <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DrvrDstrctnSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ed99XOa505a3f19f25843c4b10ed9800">
              <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eda4XOa505a3f19f25843c4b10eda300">
                  <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DrvrFtgLvl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110fefXOa505a3f19f25843c4b110fee00">
              <SHORT-NAME>DsblICE_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110ffaXOa505a3f19f25843c4b110ff900">
                  <SHORT-NAME>DsblICE_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DsblICE_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111006XOa505a3f19f25843c4b11100500">
              <SHORT-NAME>DsblISG_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111011XOa505a3f19f25843c4b11101000">
                  <SHORT-NAME>DsblISG_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DsblISG_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121b22XOa505a3f19f25843c4b121b2100">
              <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121b2eXOa505a3f19f25843c4b121b2d00">
                  <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/DschrgOptMaxPwr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102393XOa505a3f19f25843c4b10239200">
              <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10239eXOa505a3f19f25843c4b10239d00">
                  <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ECM_010ms_Group00</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102ed2XOa505a3f19f25843c4b102ed100">
              <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102eddXOa505a3f19f25843c4b102edc00">
                  <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ECM_25ms_Group36</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1023aaXOa505a3f19f25843c4b1023a900">
              <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1023b6XOa505a3f19f25843c4b1023b500">
                  <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ECM_500ms_group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102e48XOa505a3f19f25843c4b102e4700">
              <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102e53XOa505a3f19f25843c4b102e5200">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ECM_ZONE_020ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102e31XOa505a3f19f25843c4b102e3000">
              <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102e3cXOa505a3f19f25843c4b102e3b00">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ECM_ZONE_050ms_Group09</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fed9XOa505a3f19f25843c4b10fed800">
              <SHORT-NAME>EDUClntTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fee4XOa505a3f19f25843c4b10fee300">
                  <SHORT-NAME>EDUClntTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EDUClntTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fef0XOa505a3f19f25843c4b10feef00">
              <SHORT-NAME>EDUClntTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fefbXOa505a3f19f25843c4b10fefa00">
                  <SHORT-NAME>EDUClntTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EDUClntTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111fa8XOa505a3f19f25843c4b111fa700">
              <SHORT-NAME>EDUOilTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111fb3XOa505a3f19f25843c4b111fb200">
                  <SHORT-NAME>EDUOilTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EDUOilTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111fbfXOa505a3f19f25843c4b111fbe00">
              <SHORT-NAME>EDUOilTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111fcaXOa505a3f19f25843c4b111fc900">
                  <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EDUOilTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1191c2XOa505a3f19f25843c4b1191c100">
              <SHORT-NAME>ELKDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1191cdXOa505a3f19f25843c4b1191cc00">
                  <SHORT-NAME>ELKDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ELKDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108339XOa505a3f19f25843c4b10833800">
              <SHORT-NAME>ELKSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108344XOa505a3f19f25843c4b10834300">
                  <SHORT-NAME>ELKSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ELKSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1191abXOa505a3f19f25843c4b1191aa00">
              <SHORT-NAME>ELKSysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1191b6XOa505a3f19f25843c4b1191b500">
                  <SHORT-NAME>ELKSysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ELKSysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10514aXOa505a3f19f25843c4b10514900">
              <SHORT-NAME>ELKWarning</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105155XOa505a3f19f25843c4b10515400">
                  <SHORT-NAME>ELKWarning</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ELKWarning</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b122631XOa505a3f19f25843c4b12263000">
              <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b12263cXOa505a3f19f25843c4b12263b00">
                  <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EORWarningEvtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b109eceXOa505a3f19f25843c4b109ecd00">
              <SHORT-NAME>EPSAvlbly</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b109ed9XOa505a3f19f25843c4b109ed800">
                  <SHORT-NAME>EPSAvlbly</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EPSAvlbly</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b103b02XOa505a3f19f25843c4b103b0100">
              <SHORT-NAME>EPSCTTX</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b103b0dXOa505a3f19f25843c4b103b0c00">
                  <SHORT-NAME>EPSCTTX</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EPSCTTX</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101ecaXOa505a3f19f25843c4b101ec900">
              <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b101ed5XOa505a3f19f25843c4b101ed400">
                  <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/EPS_010ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101e9cXOa505a3f19f25843c4b101e9b00">
              <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b101ea7XOa505a3f19f25843c4b101ea600">
                  <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/EPS_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b101eb3XOa505a3f19f25843c4b101eb200">
              <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b101ebeXOa505a3f19f25843c4b101ebd00">
                  <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/EPS_10ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1021f5XOa505a3f19f25843c4b1021f400">
              <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102200XOa505a3f19f25843c4b1021ff00">
                  <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/EPS_10ms_Group05</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102b66XOa505a3f19f25843c4b102b6500">
              <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102b71XOa505a3f19f25843c4b102b7000">
                  <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/EPS_20ms_Group03</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10d0f0XOa505a3f19f25843c4b10d0ef00">
              <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10d0fbXOa505a3f19f25843c4b10d0fa00">
                  <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EPTClntPumpSta</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cfc5XOa505a3f19f25843c4b10cfc400">
              <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cfd0XOa505a3f19f25843c4b10cfcf00">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EPTElecWtrPumpActuSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11111aXOa505a3f19f25843c4b11111900">
              <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111125XOa505a3f19f25843c4b11112400">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCBrkRgnPwrLmt_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111131XOa505a3f19f25843c4b11113000">
              <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11113cXOa505a3f19f25843c4b11113b00">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCChrgPwrLmtPeak_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111148XOa505a3f19f25843c4b11114700">
              <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111153XOa505a3f19f25843c4b11115200">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCChrgPwrLmtWhl_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11115fXOa505a3f19f25843c4b11115e00">
              <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11116aXOa505a3f19f25843c4b11116900">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCDsChrgPwrLmtPeak_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111176XOa505a3f19f25843c4b11117500">
              <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111181XOa505a3f19f25843c4b11118000">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCDsChrgPwrLmtWhl_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11118dXOa505a3f19f25843c4b11118c00">
              <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111198XOa505a3f19f25843c4b11119700">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCEmgcyPwrDwn_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1111a4XOa505a3f19f25843c4b1111a300">
              <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1111afXOa505a3f19f25843c4b1111ae00">
                  <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCFCOReq_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1111bbXOa505a3f19f25843c4b1111ba00">
              <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1111c6XOa505a3f19f25843c4b1111c500">
                  <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCHVAllwd_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1111d2XOa505a3f19f25843c4b1111d100">
              <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1111ddXOa505a3f19f25843c4b1111dc00">
                  <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCHVHldReq_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1111e9XOa505a3f19f25843c4b1111e800">
              <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1111f4XOa505a3f19f25843c4b1111f300">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCMaxChrgPwrLmt_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111200XOa505a3f19f25843c4b1111ff00">
              <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11120bXOa505a3f19f25843c4b11120a00">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ERCMaxDschgPwrLmt_kW</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108395XOa505a3f19f25843c4b10839400">
              <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1083a0XOa505a3f19f25843c4b10839f00">
                  <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESCLPwrSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105161XOa505a3f19f25843c4b10516000">
              <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10516cXOa505a3f19f25843c4b10516b00">
                  <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESFStsForEdr</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fafcXOa505a3f19f25843c4b10fafb00">
              <SHORT-NAME>ESSAdoWrnngDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fb07XOa505a3f19f25843c4b10fb0600">
                  <SHORT-NAME>ESSAdoWrnngDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESSAdoWrnngDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f090XOa505a3f19f25843c4b10f08f00">
              <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f09bXOa505a3f19f25843c4b10f09a00">
                  <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESSAdoWrnngReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fae5XOa505a3f19f25843c4b10fae400">
              <SHORT-NAME>ESSDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10faf0XOa505a3f19f25843c4b10faef00">
                  <SHORT-NAME>ESSDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESSDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102223XOa505a3f19f25843c4b10222200">
              <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10222eXOa505a3f19f25843c4b10222d00">
                  <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/ESS_100ms_Group58</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f079XOa505a3f19f25843c4b10f07800">
              <SHORT-NAME>ESSswReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f084XOa505a3f19f25843c4b10f08300">
                  <SHORT-NAME>ESSswReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ESSswReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111217XOa505a3f19f25843c4b11121600">
              <SHORT-NAME>EVMd_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111222XOa505a3f19f25843c4b11122100">
                  <SHORT-NAME>EVMd_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EVMd_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10bb41XOa505a3f19f25843c4b10bb4000">
              <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10bb4cXOa505a3f19f25843c4b10bb4b00">
                  <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EastVelocityRTK</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b108322XOa505a3f19f25843c4b10832100">
              <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10832dXOa505a3f19f25843c4b10832c00">
                  <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/ElecPwrDistbnScene</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ec9cXOa505a3f19f25843c4b10ec9b00">
              <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10eca7XOa505a3f19f25843c4b10eca600">
                  <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/En12VoltStrMotCmddOn</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11122eXOa505a3f19f25843c4b11122d00">
              <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111239XOa505a3f19f25843c4b11123800">
                  <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngBrkTqMax_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111245XOa505a3f19f25843c4b11124400">
              <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111250XOa505a3f19f25843c4b11124f00">
                  <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngFastTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11125cXOa505a3f19f25843c4b11125b00">
              <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111267XOa505a3f19f25843c4b11126600">
                  <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngFastTqTypReq_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111273XOa505a3f19f25843c4b11127200">
              <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11127eXOa505a3f19f25843c4b11127d00">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngFlexplateTqFstTgt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11128aXOa505a3f19f25843c4b11128900">
              <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111295XOa505a3f19f25843c4b11129400">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngFlexplateTqSlowTgt_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1112a1XOa505a3f19f25843c4b1112a000">
              <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1112acXOa505a3f19f25843c4b1112ab00">
                  <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngPhsAng_deg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1112b8XOa505a3f19f25843c4b1112b700">
              <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1112c3XOa505a3f19f25843c4b1112c200">
                  <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngSlowTqReq_Nm</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1112cfXOa505a3f19f25843c4b1112ce00">
              <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1112daXOa505a3f19f25843c4b1112d900">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngSpdSafe4EngStrt_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1112e6XOa505a3f19f25843c4b1112e500">
              <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1112f1XOa505a3f19f25843c4b1112f000">
                  <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStallCnt_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1112fdXOa505a3f19f25843c4b1112fc00">
              <SHORT-NAME>EngStall_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111308XOa505a3f19f25843c4b11130700">
                  <SHORT-NAME>EngStall_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStall_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111314XOa505a3f19f25843c4b11131300">
              <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11131fXOa505a3f19f25843c4b11131e00">
                  <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStopReqCfmd_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11132bXOa505a3f19f25843c4b11132a00">
              <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111336XOa505a3f19f25843c4b11133500">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtDampSlipFailCnt_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111342XOa505a3f19f25843c4b11134100">
              <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11134dXOa505a3f19f25843c4b11134c00">
                  <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtFailCnt_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111359XOa505a3f19f25843c4b11135800">
              <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111364XOa505a3f19f25843c4b11136300">
                  <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtFail_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111370XOa505a3f19f25843c4b11136f00">
              <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11137bXOa505a3f19f25843c4b11137a00">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtNoCapFailCnt_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b111387XOa505a3f19f25843c4b11138600">
              <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111392XOa505a3f19f25843c4b11139100">
                  <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtReq_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11139eXOa505a3f19f25843c4b11139d00">
              <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1113a9XOa505a3f19f25843c4b1113a800">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EngStrtStuckFailCnt_cnt</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1216a4XOa505a3f19f25843c4b1216a300">
              <SHORT-NAME>EvtPotclSigIPD1</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1216afXOa505a3f19f25843c4b1216ae00">
                  <SHORT-NAME>EvtPotclSigIPD1</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD1</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1216bbXOa505a3f19f25843c4b1216ba00">
              <SHORT-NAME>EvtPotclSigIPD2</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1216c6XOa505a3f19f25843c4b1216c500">
                  <SHORT-NAME>EvtPotclSigIPD2</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD2</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1216d2XOa505a3f19f25843c4b1216d100">
              <SHORT-NAME>EvtPotclSigIPD3</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1216ddXOa505a3f19f25843c4b1216dc00">
                  <SHORT-NAME>EvtPotclSigIPD3</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD3</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1216e9XOa505a3f19f25843c4b1216e800">
              <SHORT-NAME>EvtPotclSigIPD4</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1216f4XOa505a3f19f25843c4b1216f300">
                  <SHORT-NAME>EvtPotclSigIPD4</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD4</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121700XOa505a3f19f25843c4b1216ff00">
              <SHORT-NAME>EvtPotclSigIPD5</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b12170bXOa505a3f19f25843c4b12170a00">
                  <SHORT-NAME>EvtPotclSigIPD5</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD5</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121717XOa505a3f19f25843c4b12171600">
              <SHORT-NAME>EvtPotclSigIPD6</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121722XOa505a3f19f25843c4b12172100">
                  <SHORT-NAME>EvtPotclSigIPD6</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD6</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b12172eXOa505a3f19f25843c4b12172d00">
              <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121739XOa505a3f19f25843c4b12173800">
                  <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD7</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b121745XOa505a3f19f25843c4b12174400">
              <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b121750XOa505a3f19f25843c4b12174f00">
                  <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/EvtPotclSigIPD8</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c646XOa505a3f19f25843c4b11c64500">
              <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c651XOa505a3f19f25843c4b11c65000">
                  <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTBSysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c6d0XOa505a3f19f25843c4b11c6cf00">
              <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c6dbXOa505a3f19f25843c4b11c6da00">
                  <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTBSysFltSts_ADAS</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f695XOa505a3f19f25843c4b10f69400">
              <SHORT-NAME>FCTSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f6a0XOa505a3f19f25843c4b10f69f00">
                  <SHORT-NAME>FCTSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c674XOa505a3f19f25843c4b11c67300">
              <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c67fXOa505a3f19f25843c4b11c67e00">
                  <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTSwSts_ADAS</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f6acXOa505a3f19f25843c4b10f6ab00">
              <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f6b7XOa505a3f19f25843c4b10f6b600">
                  <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTSysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11c6b9XOa505a3f19f25843c4b11c6b800">
              <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11c6c4XOa505a3f19f25843c4b11c6c300">
                  <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTSysFltSts_ADAS</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ef7cXOa505a3f19f25843c4b10ef7b00">
              <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ef87XOa505a3f19f25843c4b10ef8600">
                  <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCTSysSelReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105178XOa505a3f19f25843c4b10517700">
              <SHORT-NAME>FCWDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105183XOa505a3f19f25843c4b10518200">
                  <SHORT-NAME>FCWDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1051a6XOa505a3f19f25843c4b1051a500">
              <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1051b1XOa505a3f19f25843c4b1051b000">
                  <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWSnstvtLvl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1083acXOa505a3f19f25843c4b1083ab00">
              <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1083b7XOa505a3f19f25843c4b1083b600">
                  <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWSnstvtLvlReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1083c3XOa505a3f19f25843c4b1083c200">
              <SHORT-NAME>FCWSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1083ceXOa505a3f19f25843c4b1083cd00">
                  <SHORT-NAME>FCWSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1051bdXOa505a3f19f25843c4b1051bc00">
              <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1051c8XOa505a3f19f25843c4b1051c700">
                  <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWSysFltSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10518fXOa505a3f19f25843c4b10518e00">
              <SHORT-NAME>FCWrnngSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10519aXOa505a3f19f25843c4b10519900">
                  <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FCWrnngSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1083daXOa505a3f19f25843c4b1083d900">
              <SHORT-NAME>FDRPwrSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1083e5XOa505a3f19f25843c4b1083e400">
                  <SHORT-NAME>FDRPwrSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FDRPwrSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1025d4XOa505a3f19f25843c4b1025d300">
              <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1025dfXOa505a3f19f25843c4b1025de00">
                  <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/FDR_100ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105bb8XOa505a3f19f25843c4b105bb700">
              <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105bc3XOa505a3f19f25843c4b105bc200">
                  <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLDircnLghtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b8bbXOa505a3f19f25843c4b10b8ba00">
              <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b8c6XOa505a3f19f25843c4b10b8c500">
                  <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLDoorHndlPESwtActv</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b8e3XOa505a3f19f25843c4b11b8e200">
              <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b8eeXOa505a3f19f25843c4b11b8ed00">
                  <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLDoorOpenSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f411XOa505a3f19f25843c4b10f41000">
              <SHORT-NAME>FLObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f41cXOa505a3f19f25843c4b10f41b00">
                  <SHORT-NAME>FLObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10fa89XOa505a3f19f25843c4b10fa8800">
              <SHORT-NAME>FLSObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10fa94XOa505a3f19f25843c4b10fa9300">
                  <SHORT-NAME>FLSObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLSObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f9d1XOa505a3f19f25843c4b10f9d000">
              <SHORT-NAME>FLSUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f9dcXOa505a3f19f25843c4b10f9db00">
                  <SHORT-NAME>FLSUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLSUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f53cXOa505a3f19f25843c4b10f53b00">
              <SHORT-NAME>FLSideObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f547XOa505a3f19f25843c4b10f54600">
                  <SHORT-NAME>FLSideObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLSideObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b4f5XOa505a3f19f25843c4b10b4f400">
              <SHORT-NAME>FLTirePrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b500XOa505a3f19f25843c4b10b4ff00">
                  <SHORT-NAME>FLTirePrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLTirePrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b50cXOa505a3f19f25843c4b10b50b00">
              <SHORT-NAME>FLTirePrsV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b517XOa505a3f19f25843c4b10b51600">
                  <SHORT-NAME>FLTirePrsV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLTirePrsV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f498f2acb34cbaXNa505a3f19f498f2acb34cb400">
              <SHORT-NAME>FLTireSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f498f2acb34cc7XNa505a3f19f498f2acb34cc100">
                  <SHORT-NAME>FLTireSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLTireSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110863XOa505a3f19f25843c4b11086200">
              <SHORT-NAME>FLTireTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11086eXOa505a3f19f25843c4b11086d00">
                  <SHORT-NAME>FLTireTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLTireTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11087aXOa505a3f19f25843c4b11087900">
              <SHORT-NAME>FLTireTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b110885XOa505a3f19f25843c4b11088400">
                  <SHORT-NAME>FLTireTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLTireTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f975XOa505a3f19f25843c4b10f97400">
              <SHORT-NAME>FLUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f980XOa505a3f19f25843c4b10f97f00">
                  <SHORT-NAME>FLUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10875bXOa505a3f19f25843c4b10875a00">
              <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b108766XOa505a3f19f25843c4b10876500">
                  <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FLiDARPwrSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f98cXOa505a3f19f25843c4b10f98b00">
              <SHORT-NAME>FMLUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f997XOa505a3f19f25843c4b10f99600">
                  <SHORT-NAME>FMLUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FMLUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f9a3XOa505a3f19f25843c4b10f9a200">
              <SHORT-NAME>FMRUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f9aeXOa505a3f19f25843c4b10f9ad00">
                  <SHORT-NAME>FMRUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FMRUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10587cXOa505a3f19f25843c4b10587b00">
              <SHORT-NAME>FOTAStatus</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105887XOa505a3f19f25843c4b10588600">
                  <SHORT-NAME>FOTAStatus</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FOTAStatus</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105893XOa505a3f19f25843c4b10589200">
              <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10589eXOa505a3f19f25843c4b10589d00">
                  <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FOTAStatusValid</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f25cXOa505a3f19f25843c4b10f25b00">
              <SHORT-NAME>FOTATarget</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f267XOa505a3f19f25843c4b10f26600">
                  <SHORT-NAME>FOTATarget</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FOTATarget</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f273XOa505a3f19f25843c4b10f27200">
              <SHORT-NAME>FOTATargetValid</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f27eXOa505a3f19f25843c4b10f27d00">
                  <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FOTATargetValid</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b107660XOa505a3f19f25843c4b10765f00">
              <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10766bXOa505a3f19f25843c4b10766a00">
                  <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRDircnLghtSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b8d2XOa505a3f19f25843c4b10b8d100">
              <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b8ddXOa505a3f19f25843c4b10b8dc00">
                  <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRDoorHndlPESwtActv</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b8faXOa505a3f19f25843c4b11b8f900">
              <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b905XOa505a3f19f25843c4b11b90400">
                  <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRDoorOpenSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f428XOa505a3f19f25843c4b10f42700">
              <SHORT-NAME>FRObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f433XOa505a3f19f25843c4b10f43200">
                  <SHORT-NAME>FRObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10faa0XOa505a3f19f25843c4b10fa9f00">
              <SHORT-NAME>FRSObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10faabXOa505a3f19f25843c4b10faaa00">
                  <SHORT-NAME>FRSObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRSObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f9baXOa505a3f19f25843c4b10f9b900">
              <SHORT-NAME>FRSUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f9c5XOa505a3f19f25843c4b10f9c400">
                  <SHORT-NAME>FRSUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRSUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f553XOa505a3f19f25843c4b10f55200">
              <SHORT-NAME>FRSideObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f55eXOa505a3f19f25843c4b10f55d00">
                  <SHORT-NAME>FRSideObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRSideObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b523XOa505a3f19f25843c4b10b52200">
              <SHORT-NAME>FRTirePrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b52eXOa505a3f19f25843c4b10b52d00">
                  <SHORT-NAME>FRTirePrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRTirePrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10b53aXOa505a3f19f25843c4b10b53900">
              <SHORT-NAME>FRTirePrsV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10b545XOa505a3f19f25843c4b10b54400">
                  <SHORT-NAME>FRTirePrsV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRTirePrsV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Na505a3f19f498f2acb350e0XNa505a3f19f498f2acb350da00">
              <SHORT-NAME>FRTireSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Na505a3f19f498f2acb350edXNa505a3f19f498f2acb350e700">
                  <SHORT-NAME>FRTireSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRTireSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b110891XOa505a3f19f25843c4b11089000">
              <SHORT-NAME>FRTireTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11089cXOa505a3f19f25843c4b11089b00">
                  <SHORT-NAME>FRTireTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRTireTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1108a8XOa505a3f19f25843c4b1108a700">
              <SHORT-NAME>FRTireTemV</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1108b3XOa505a3f19f25843c4b1108b200">
                  <SHORT-NAME>FRTireTemV</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRTireTemV</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f9e8XOa505a3f19f25843c4b10f9e700">
              <SHORT-NAME>FRUSSSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f9f3XOa505a3f19f25843c4b10f9f200">
                  <SHORT-NAME>FRUSSSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FRUSSSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102561XOa505a3f19f25843c4b10256000">
              <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10256cXOa505a3f19f25843c4b10256b00">
                  <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/FVCM_10ms_Group01</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b102ac5XOa505a3f19f25843c4b102ac400">
              <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b102ad0XOa505a3f19f25843c4b102acf00">
                  <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                  <TYPE-TREF DEST="IMPLEMENTATION-DATA-TYPE">/DataTypes/ImplementationDataTypes/FVCM_20ms_Group02</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1225beXOa505a3f19f25843c4b1225bd00">
              <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1225c9XOa505a3f19f25843c4b1225c800">
                  <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtCamrHeatCtrl</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1225d5XOa505a3f19f25843c4b1225d400">
              <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1225e0XOa505a3f19f25843c4b1225df00">
                  <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtCamrHeatSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f314XOa505a3f19f25843c4b10f31300">
              <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f31fXOa505a3f19f25843c4b10f31e00">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtCarGoNotfrDspCmd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10ee3aXOa505a3f19f25843c4b10ee3900">
              <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10ee45XOa505a3f19f25843c4b10ee4400">
                  <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtCarGoNotfrSwReq</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f43fXOa505a3f19f25843c4b10f43e00">
              <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f44aXOa505a3f19f25843c4b10f44900">
                  <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtMidLObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f456XOa505a3f19f25843c4b10f45500">
              <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f461XOa505a3f19f25843c4b10f46000">
                  <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtMidRObsRng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f4c9XOa505a3f19f25843c4b10f4c800">
              <SHORT-NAME>FrtObsDist</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f4d4XOa505a3f19f25843c4b10f4d300">
                  <SHORT-NAME>FrtObsDist</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtObsDist</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10f50eXOa505a3f19f25843c4b10f50d00">
              <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10f519XOa505a3f19f25843c4b10f51800">
                  <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtPDCAudWrnng</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b8b5XOa505a3f19f25843c4b11b8b400">
              <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b8c0XOa505a3f19f25843c4b11b8bf00">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtPsngDoorOpenSts_LHZCU</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b11b887XOa505a3f19f25843c4b11b88600">
              <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b11b892XOa505a3f19f25843c4b11b89100">
                  <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtTireStdPrs</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cf3bXOa505a3f19f25843c4b10cf3a00">
              <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf46XOa505a3f19f25843c4b10cf4500">
                  <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtWindShldSfcTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cf52XOa505a3f19f25843c4b10cf5100">
              <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf5dXOa505a3f19f25843c4b10cf5c00">
                  <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtWindShldSurndHmdty</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b10cf69XOa505a3f19f25843c4b10cf6800">
              <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b10cf74XOa505a3f19f25843c4b10cf7300">
                  <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtWindShldSurndTem</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105cccXOa505a3f19f25843c4b105ccb00">
              <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105cd7XOa505a3f19f25843c4b105cd600">
                  <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtWiperSpd</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b105ce3XOa505a3f19f25843c4b105ce200">
              <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b105ceeXOa505a3f19f25843c4b105ced00">
                  <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FrtWiperSwSts</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1113ccXOa505a3f19f25843c4b1113cb00">
              <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1113d7XOa505a3f19f25843c4b1113d600">
                  <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FuCutReq_enum</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1113e3XOa505a3f19f25843c4b1113e200">
              <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b1113eeXOa505a3f19f25843c4b1113ed00">
                  <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
                  <TYPE-TREF DEST="APPLICATION-PRIMITIVE-DATA-TYPE">/DataTypes/ApplicationDataTypes/FulCutDMFPrdtn_flg</TYPE-TREF>
                </VARIABLE-DATA-PROTOTYPE>
              </DATA-ELEMENTS>
            </SENDER-RECEIVER-INTERFACE>
            <SENDER-RECEIVER-INTERFACE UUID="Oa505a3f19f25843c4b1113faXOa505a3f19f25843c4b1113f900">
              <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
              <IS-SERVICE>false</IS-SERVICE>
              <DATA-ELEMENTS>
                <VARIABLE-DATA-PROTOTYPE UUID="Oa505a3f19f25843c4b111405XOa505a3f19f25843c4b11140400">
                  <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
