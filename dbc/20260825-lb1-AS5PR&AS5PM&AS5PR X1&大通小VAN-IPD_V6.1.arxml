                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMSSta_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1e0f3f9b22f730b3854fa2b6ce73d3d4">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD_MComposition_IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f4e971fc9939309f86b3d6b4144d5e46">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD_MComposition_IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa801a16b3f33ce5af0f8577838c6947">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD_MComposition_IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6cf603e8269935568b1e7a46d67cf560">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD_MComposition_IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RMStoNOS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc559bca9bf939ff948c40479accb687">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD_MComposition_IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="66d91702b0fe3888a9e26d7d3fa7202a">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD_MComposition_IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1bf9e0744d513c1e9c3bc3f1f1610150">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD_MComposition_IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d80210ceea443d2bb89e6260d101a36a">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD_MComposition_IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoNOS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="903ddacc0a513db8a59d00270cf4151a">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD_MComposition_IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d618c0d32f83914a3864d04f7e0b038">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD_MComposition_IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bde546d42ff63ea8a71cbb48de0272dd">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD_MComposition_IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="92f49a54ddad3ad69d10b335be206a89">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD_MComposition_IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_RSStoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="07030a47de343fb4a108a3023ab1ec29">
                  <SHORT-NAME>IPD_NOI_BKPCANFD_MComposition_IPD_NOI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eead493f7f0435f996f055535b8e2f53">
                  <SHORT-NAME>IPD_NOI_CHCANFD_MComposition_IPD_NOI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9204b34b8842332e8bc30d3f182fbbbd">
                  <SHORT-NAME>IPD_NOI_PTCANFD_MComposition_IPD_NOI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78f455ead4bd3f56a4abffb462238db1">
                  <SHORT-NAME>IPD_NOI_SFCANFD_MComposition_IPD_NOI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NOI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e6a58a30e2183356b4a77ba2074dcdcd">
                  <SHORT-NAME>IPD_NWI_BKPCANFD_MComposition_IPD_NWI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48dea0a66eb63f7999f27c7dc1e61351">
                  <SHORT-NAME>IPD_NWI_CHCANFD_MComposition_IPD_NWI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="747a4f909fd93b1aa48e07cc56a7b79b">
                  <SHORT-NAME>IPD_NWI_PTCANFD_MComposition_IPD_NWI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7d179e4758373ab39c4c79bb0c4e5287">
                  <SHORT-NAME>IPD_NWI_SFCANFD_MComposition_IPD_NWI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NWI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb9724bd3b5a3d918434f63e6407435b">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group_MComposition_IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_Sporadic_TimeSync_Group</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_Sporadic_TimeSync_Group</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cb295b00d1413f7c80358077df12e56a">
                  <SHORT-NAME>IPD_VehLckCtrlReq_MComposition_IPD_VehLckCtrlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_VehLckCtrlReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_VehLckCtrlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e7aa1716762235769ba0dd75ef293709">
                  <SHORT-NAME>ISGMaxTqLmt_Nm_MComposition_ISGMaxTqLmt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGMaxTqLmt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGMaxTqLmt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e54bb1fe0d13829b89197d4c3510f83">
                  <SHORT-NAME>ISGMinTqLmt_Nm_MComposition_ISGMinTqLmt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGMinTqLmt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGMinTqLmt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="695654af4f5c3b16bf3e9e9d0368fb61">
                  <SHORT-NAME>ISGTqTgt_Nm_MComposition_ISGTqTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGTqTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ISGTqTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="088bb6ccfab63de0bdb66c843e653215">
                  <SHORT-NAME>IdentityChlg_MComposition_IdentityChlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IdentityChlg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IdentityChlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3d8e86de9af730e2ae8067212f34c79c">
                  <SHORT-NAME>IgnOffTimeV_MComposition_IgnOffTimeV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IgnOffTimeV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IgnOffTimeV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59056e9df4023232892eae0c3879c1a7">
                  <SHORT-NAME>IgnOffTime_MComposition_IgnOffTime</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IgnOffTime</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IgnOffTime</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca6f465a747b30f19cc243de93753ba7">
                  <SHORT-NAME>JAMsgReq_MComposition_JAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/JAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/JAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="44a98e9aa4a03106a48bd659a0d0c2bc">
                  <SHORT-NAME>LADSCurToEndPntDist_MComposition_LADSCurToEndPntDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LADSCurToEndPntDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LADSCurToEndPntDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="79c7033fcd603451b07de7179075bd5f">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP_MComposition_LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LADSInfoDispReqToICM_HPP</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LADSInfoDispReqToICM_HPP</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e2dece54294c3b389992d96cb72b91c5">
                  <SHORT-NAME>LCASelReq_MComposition_LCASelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCASelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCASelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="01eb633eb61333f892e236dd9d524a85">
                  <SHORT-NAME>LCRInHMI_MComposition_LCRInHMI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRInHMI</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRInHMI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ed4bde9b885397f9f473330d5a253a3">
                  <SHORT-NAME>LCRSwDspCmd_MComposition_LCRSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bf33a079c7983ef1ae4dc0009e3d87c6">
                  <SHORT-NAME>LCRSwReq_MComposition_LCRSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LCRSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed056550d0a53f4ba5905311303af1cb">
                  <SHORT-NAME>LDWAdoWrnngReq_MComposition_LDWAdoWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWAdoWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWAdoWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e19d6c377453a74bba7e39062c706cf">
                  <SHORT-NAME>LDWLKAHptWrnngReq_MComposition_LDWLKAHptWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWLKAHptWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWLKAHptWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f303ee4eb5d83a689e28f1a072a301bb">
                  <SHORT-NAME>LDWLKASwReq_MComposition_LDWLKASwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWLKASwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWLKASwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa1be9907ce336e9b1665d656887ce40">
                  <SHORT-NAME>LDWSnstvtLvlReq_MComposition_LDWSnstvtLvlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWSnstvtLvlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWSnstvtLvlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="961772da988f3579bd24a03785b8b7be">
                  <SHORT-NAME>LDWStsForEdr_MComposition_LDWStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LDWStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ee953c737ff53dc7822a1d078ef3af5d">
                  <SHORT-NAME>LFCTWrnng_ADAS_MComposition_LFCTWrnng_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LFCTWrnng_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LFCTWrnng_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="88d78292c93c3ad6ae6d510bd4b2550e">
                  <SHORT-NAME>LFCTWrnng_MComposition_LFCTWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LFCTWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LFCTWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d37169c9c9293822a72224f572ee39e7">
                  <SHORT-NAME>LHSWPwrSts_MComposition_LHSWPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHSWPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHSWPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a9371f652de637759c85f22099714a16">
                  <SHORT-NAME>LHZCUAvlbly_MComposition_LHZCUAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCUAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCUAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2138d393f7583f8c800fce52ee9f449e">
                  <SHORT-NAME>LHZCU_100ms_Group30_MComposition_LHZCU_100ms_Group30</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_100ms_Group30</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_100ms_Group30</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0ab1bd8734553c15970996cb1ed8f238">
                  <SHORT-NAME>LHZCU_10ms_Group01_MComposition_LHZCU_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="edd7daf60e0a34fc801a362d151a93e5">
                  <SHORT-NAME>LHZCU_10ms_Group32_MComposition_LHZCU_10ms_Group32</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_10ms_Group32</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_10ms_Group32</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cf71ea5cf8ca30ce9ac3af95a8f4b961">
                  <SHORT-NAME>LHZCU_20ms_Group03_MComposition_LHZCU_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4c59b9016e503579b8c154034081cf10">
                  <SHORT-NAME>LHZCU_400ms_Group18_MComposition_LHZCU_400ms_Group18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_400ms_Group18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_400ms_Group18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce85c40694ac3414a236dc8736fbdc23">
                  <SHORT-NAME>LHZCU_50ms_Group06_MComposition_LHZCU_50ms_Group06</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_50ms_Group06</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_50ms_Group06</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6aabc565c326304082c15c0f7611d439">
                  <SHORT-NAME>LHZCU_50ms_Group24_MComposition_LHZCU_50ms_Group24</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_50ms_Group24</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/LHZCU_50ms_Group24</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ea4d305ebac63dcf9d76cba3d4c7a536">
                  <SHORT-NAME>Lane0_C0_MComposition_Lane0_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34a857ad60713d1eb817b642a4c88577">
                  <SHORT-NAME>Lane0_C1_MComposition_Lane0_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="341973d7b32232fb918d83d9cf01afe9">
                  <SHORT-NAME>Lane0_C2_MComposition_Lane0_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="318b6ecae907350e84b5797607d54b6d">
                  <SHORT-NAME>Lane0_C3_MComposition_Lane0_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d13e60401d7937d3b307b11208c99842">
                  <SHORT-NAME>Lane0_ExistPrblty_MComposition_Lane0_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="596aa67460873978bcb1cf6224e73d88">
                  <SHORT-NAME>Lane0_ID_MComposition_Lane0_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="80cc8a1fbc073a9ca8e2878c56bc113f">
                  <SHORT-NAME>Lane0_MarkerColor_MComposition_Lane0_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ef70e62299c63acc91b0b0667879fec4">
                  <SHORT-NAME>Lane0_MarkerType_MComposition_Lane0_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5fb0d05de84c3eaf8283c5735bb83678">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex_MComposition_Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a900d0ca2b3390cbeeaa0260945e08c">
                  <SHORT-NAME>Lane0_ViewRangeEnd_MComposition_Lane0_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3dd4515a002c356d92f50bdb08e81ac7">
                  <SHORT-NAME>Lane0_ViewRangeStart_MComposition_Lane0_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="771aa8d3770e3919b6678efd9f045b59">
                  <SHORT-NAME>Lane0_location_MComposition_Lane0_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane0_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4fe31d2082a73012a516938d5d4f9dee">
                  <SHORT-NAME>Lane1_C0_MComposition_Lane1_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="86d398565cfc35589c69ccf7ffc4e3a0">
                  <SHORT-NAME>Lane1_C1_MComposition_Lane1_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f70f9db443b13fa0bd99ccd2032be0fd">
                  <SHORT-NAME>Lane1_C2_MComposition_Lane1_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3fad4249d595341bb0a8f9affcfd0c17">
                  <SHORT-NAME>Lane1_C3_MComposition_Lane1_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="954326c2887830f6886ff3b0d5968a17">
                  <SHORT-NAME>Lane1_ExistPrblty_MComposition_Lane1_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="95f293b25ad030f29e7b7951a62bca6e">
                  <SHORT-NAME>Lane1_ID_MComposition_Lane1_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="61d070f7861c36a9b7e6c35913b4cb90">
                  <SHORT-NAME>Lane1_MarkerColor_MComposition_Lane1_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="148b0497ba3c34efb4adb9029d38083e">
                  <SHORT-NAME>Lane1_MarkerType_MComposition_Lane1_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e3727b3c92dc3be1bc4427184c868552">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex_MComposition_Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4ceba1be8095395090ffba3d3988904c">
                  <SHORT-NAME>Lane1_ViewRangeEnd_MComposition_Lane1_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="df450e48c4193273961b74ca112d4fa7">
                  <SHORT-NAME>Lane1_ViewRangeStart_MComposition_Lane1_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="46eb635c6a9834df8e42888b6247ab98">
                  <SHORT-NAME>Lane1_location_MComposition_Lane1_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane1_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8d046a31586f3f9f9dc1315a721f75a0">
                  <SHORT-NAME>Lane2_C0_MComposition_Lane2_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fb9d12ec968131279c6d751a2be42a67">
                  <SHORT-NAME>Lane2_C1_MComposition_Lane2_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f51783cab6443c588fe8ab36cdda9c92">
                  <SHORT-NAME>Lane2_C2_MComposition_Lane2_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7440f346d0d63be0bd381daa5a8353a7">
                  <SHORT-NAME>Lane2_C3_MComposition_Lane2_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c6076bcf7c3f31cd887fa8a5bfbb1085">
                  <SHORT-NAME>Lane2_ExistPrblty_MComposition_Lane2_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3fbb0a4a20743980aab5a5ba6124d939">
                  <SHORT-NAME>Lane2_ID_MComposition_Lane2_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f37951c7eee33482bcc1731520078afc">
                  <SHORT-NAME>Lane2_MarkerColor_MComposition_Lane2_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="563f1e5a664631c99099b69ed944eda2">
                  <SHORT-NAME>Lane2_MarkerType_MComposition_Lane2_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7aa02fd9ab73354699b9307d047d3523">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex_MComposition_Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="66f63279edf63f07961e45686797038f">
                  <SHORT-NAME>Lane2_ViewRangeEnd_MComposition_Lane2_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="39598230972e37858670bac3368926bc">
                  <SHORT-NAME>Lane2_ViewRangeStart_MComposition_Lane2_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="345cdec256803355adf3a2b6a1cc0193">
                  <SHORT-NAME>Lane2_location_MComposition_Lane2_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane2_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a882cbfae8c43b6cae54c5cb4bff79da">
                  <SHORT-NAME>Lane3_C0_MComposition_Lane3_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8a2416b33cb93a71bcd0aa9cb321fd1c">
                  <SHORT-NAME>Lane3_C1_MComposition_Lane3_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d1e0f384eaee3ccc9f3ad9348d1baa8a">
                  <SHORT-NAME>Lane3_C2_MComposition_Lane3_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce0d24a5ed7436aeb4decef74f3b00d5">
                  <SHORT-NAME>Lane3_C3_MComposition_Lane3_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="893343d5fc6132a28706bfb3bdd109b4">
                  <SHORT-NAME>Lane3_ExistPrblty_MComposition_Lane3_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="76169692d9203264981334c76f1f32fd">
                  <SHORT-NAME>Lane3_ID_MComposition_Lane3_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de865d710de43fa296c8961c128a0606">
                  <SHORT-NAME>Lane3_MarkerColor_MComposition_Lane3_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="139547d2d29d3af49f74e5a0c8e6a89b">
                  <SHORT-NAME>Lane3_MarkerType_MComposition_Lane3_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6a5b8da2af6433eab5461eb57fdd1af5">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex_MComposition_Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a6b41fe7f743059a19d63790fcd56a4">
                  <SHORT-NAME>Lane3_ViewRangeEnd_MComposition_Lane3_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="939f00531c7134f6a0f46337519a167b">
                  <SHORT-NAME>Lane3_ViewRangeStart_MComposition_Lane3_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a87b07f2846532f7b4f7af203bfcb152">
                  <SHORT-NAME>Lane3_location_MComposition_Lane3_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Lane3_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c4e416d6f44e3c6d83011536ae2aaaca">
                  <SHORT-NAME>MONSAMTqReq_Nm_MComposition_MONSAMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MONSAMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MONSAMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db02b9d1caac35d48c94e084248bdfc1">
                  <SHORT-NAME>MONTMTqReq_Nm_MComposition_MONTMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MONTMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MONTMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4918493304de3b48826add52e22fe763">
                  <SHORT-NAME>MainBeamLghtOn_MComposition_MainBeamLghtOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MainBeamLghtOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MainBeamLghtOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3016a4245dcd38179b2740593c4e7f71">
                  <SHORT-NAME>MemParkngBtnRcnm_MComposition_MemParkngBtnRcnm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemParkngBtnRcnm</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemParkngBtnRcnm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ea98e5f9c81a3b68a379a2caf88610a3">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq_MComposition_MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemPkngSlntPtrlEnbSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemPkngSlntPtrlEnbSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a57ded8e8db23687be0811d8b9071252">
                  <SHORT-NAME>MemPkngSwReq_MComposition_MemPkngSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemPkngSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MemPkngSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="458f49a276d8392d877aa33c0f0641d7">
                  <SHORT-NAME>MnvrngPntDistNav_MComposition_MnvrngPntDistNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MnvrngPntDistNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MnvrngPntDistNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eba48460d47b3db49bab15907a495b28">
                  <SHORT-NAME>MnvrngPntTypNav_MComposition_MnvrngPntTypNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MnvrngPntTypNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MnvrngPntTypNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1a8cab601f3738ce8199a84952ee0a96">
                  <SHORT-NAME>NOACitySysMsg_MComposition_NOACitySysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOACitySysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOACitySysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="01181cd9cf7736a4a4d5f7fed404fa77">
                  <SHORT-NAME>NOADistDecMsg_MComposition_NOADistDecMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOADistDecMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOADistDecMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d166f4041b3395795a56d989a6e630b">
                  <SHORT-NAME>NOAETCSetDspCmd_MComposition_NOAETCSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAETCSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAETCSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="49a6c3a2b29433e7b6e061828c345a6c">
                  <SHORT-NAME>NOAETCSetSwReq_MComposition_NOAETCSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAETCSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAETCSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed6b8024707b3556aaa146a627f3f66c">
                  <SHORT-NAME>NOALaneSetDspCmd_MComposition_NOALaneSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOALaneSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOALaneSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e1ebe28bb85b360e849c9a9f8f8ac1c0">
                  <SHORT-NAME>NOALaneSetSwReq_MComposition_NOALaneSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOALaneSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOALaneSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c35ecef18d123990b771506c260c96a6">
                  <SHORT-NAME>NOAQukChgSwDspCmd_MComposition_NOAQukChgSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAQukChgSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAQukChgSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="61934c137d5c3bac852304fa51da8cad">
                  <SHORT-NAME>NOAQukChgSwReq_MComposition_NOAQukChgSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAQukChgSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAQukChgSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48241ff32bf23892b3a0334491bc6dcd">
                  <SHORT-NAME>NOAReportSetDspCmd_MComposition_NOAReportSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAReportSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAReportSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed6bb7a130003aef83253c8406037d4d">
                  <SHORT-NAME>NOAReportSetSwReq_MComposition_NOAReportSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAReportSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOAReportSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2470e86ee40939db9d72708605752b13">
                  <SHORT-NAME>NOPCitySwDspCmd_MComposition_NOPCitySwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPCitySwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPCitySwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7653a963b7a13e8ab503151d57639add">
                  <SHORT-NAME>NOPCitySwReq_MComposition_NOPCitySwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPCitySwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPCitySwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d3d995d90783ead90d208cb45d0fb49">
                  <SHORT-NAME>NOPSwDspCmd_MComposition_NOPSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2dedcc8ab6a73f12969afbb658ba2b8a">
                  <SHORT-NAME>NOPSwReq_MComposition_NOPSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c374bb996bfd31aabbf2ee510f3e0ff7">
                  <SHORT-NAME>NOPSysMsg_MComposition_NOPSysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NOPSysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0923c599803c3d4baf4b4dc867e6085c">
                  <SHORT-NAME>NarRoVslAssQuit_MComposition_NarRoVslAssQuit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssQuit</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssQuit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd60e7f867c1359996cce0757b16afa9">
                  <SHORT-NAME>NarRoVslAssSwReq_MComposition_NarRoVslAssSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f6222942b4a3783a4fffa23416ce637">
                  <SHORT-NAME>NarRoVslAssSwResp_MComposition_NarRoVslAssSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarRoVslAssSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d4d7778640e3339b3c0125afb07b468">
                  <SHORT-NAME>NarrowRoadBackwardSts_MComposition_NarrowRoadBackwardSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarrowRoadBackwardSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarrowRoadBackwardSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d58c34618ac731f1a9ad8453f2411562">
                  <SHORT-NAME>NarrowRoadForwardSts_MComposition_NarrowRoadForwardSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarrowRoadForwardSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarrowRoadForwardSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a7d389f35362354c86a9f6980a33fc96">
                  <SHORT-NAME>NarwSpcAstBtnSts_MComposition_NarwSpcAstBtnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstBtnSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstBtnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1f8163b1b9a836c0bc591def270dae0a">
                  <SHORT-NAME>NarwSpcAstSwReq_MComposition_NarwSpcAstSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="808076787af6319d8e936134aa800ed1">
                  <SHORT-NAME>NarwSpcAstSwSts_MComposition_NarwSpcAstSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NarwSpcAstSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e2cf81fa18b93ea4acb055ab9aeabe3b">
                  <SHORT-NAME>NavCndSpdLmtVal_MComposition_NavCndSpdLmtVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCndSpdLmtVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCndSpdLmtVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a37d5d101b2c3661b62d271917ce8375">
                  <SHORT-NAME>NavCrntRoadTyp_MComposition_NavCrntRoadTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCrntRoadTyp</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCrntRoadTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b51698f06b3739868d0104e3f87787f6">
                  <SHORT-NAME>NavCtryCode_ISO_MComposition_NavCtryCode_ISO</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCtryCode_ISO</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavCtryCode_ISO</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bccf593259ee36f89234881bcede082d">
                  <SHORT-NAME>NavDistFromFrtEleccEye_MComposition_NavDistFromFrtEleccEye</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavDistFromFrtEleccEye</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavDistFromFrtEleccEye</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e58c56b6fb7e3549aa91d30802d35924">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist_MComposition_NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavItvalSpdDetnDistRetDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavItvalSpdDetnDistRetDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9ac451bcb45b374e9595845f7a5d173f">
                  <SHORT-NAME>NavNewIconDist_MComposition_NavNewIconDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavNewIconDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavNewIconDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4173c772693d3f1c8d9f84fe079e7307">
                  <SHORT-NAME>NavNextRampOffset_MComposition_NavNextRampOffset</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavNextRampOffset</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavNextRampOffset</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aa46d37ef19b3a0ca312f6961a67166f">
                  <SHORT-NAME>NavSpdLmtTyp_MComposition_NavSpdLmtTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtTyp</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f31d115938d3a1a92d5ceef13ae1644">
                  <SHORT-NAME>NavSpdLmtValSts_MComposition_NavSpdLmtValSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtValSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtValSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="523cbcec1ac23752a45440850d5c09a3">
                  <SHORT-NAME>NavSpdLmtValUnit_MComposition_NavSpdLmtValUnit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtValUnit</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtValUnit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9eb84d1b1418335786c30cdabf598649">
                  <SHORT-NAME>NavSpdLmtVal_MComposition_NavSpdLmtVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSpdLmtVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3d99161836c73e8b899a10137aff3d46">
                  <SHORT-NAME>NavSts_MComposition_NavSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NavSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c55b560228be393d88636f06c1a9b5d0">
                  <SHORT-NAME>NonDirectDMSSwDspCmd_MComposition_NonDirectDMSSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9aaf4a778f23ad69145db45b35c93af">
                  <SHORT-NAME>NonDirectDMSSwReq_MComposition_NonDirectDMSSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="178eee5af4eb31289d50880cce5393a6">
                  <SHORT-NAME>NonDirectDMSSysSts_MComposition_NonDirectDMSSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NonDirectDMSSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9155b838a4383d7e88cf0de13f9380d0">
                  <SHORT-NAME>NorthVelocityRTK_MComposition_NorthVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NorthVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NorthVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="333bb11c97543e97a6abbb3713c80e8f">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd_MComposition_NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssConfrmSwDscmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssConfrmSwDscmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="82d20515abe539ddb2994eedce416faa">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq_MComposition_NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssConfrmSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssConfrmSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="13774f8fd0ad3531b7daa74ca89d30b7">
                  <SHORT-NAME>NrwroadBwdAssMesg_MComposition_NrwroadBwdAssMesg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssMesg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssMesg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="42a5edcfafdb3f11a1a8fb841fc20dd6">
                  <SHORT-NAME>NrwroadBwdAssSwReq_MComposition_NrwroadBwdAssSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93d66411938c36b49c919ae2b84fcd14">
                  <SHORT-NAME>NrwroadBwdAssSwSts_MComposition_NrwroadBwdAssSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadBwdAssSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="84f467f77a6433bfb6c6f6017b83761b">
                  <SHORT-NAME>NrwroadFwdBtnDsp_MComposition_NrwroadFwdBtnDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdBtnDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdBtnDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="20918ff37b0e31bd86c0da79cc866972">
                  <SHORT-NAME>NrwroadFwdCndNotSt_MComposition_NrwroadFwdCndNotSt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdCndNotSt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdCndNotSt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d2c43156c549398fac4fef1912544c35">
                  <SHORT-NAME>NrwroadFwdCtlReq_MComposition_NrwroadFwdCtlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdCtlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdCtlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6a2776a0853c3cb79082f1c9dbe6d9b5">
                  <SHORT-NAME>NrwroadFwdDsp_MComposition_NrwroadFwdDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="362f5bc9abf6336293724c20a0c2cada">
                  <SHORT-NAME>NrwroadFwdDst360Req_MComposition_NrwroadFwdDst360Req</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDst360Req</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDst360Req</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2bf8aa48ea94354d988e1b1bccc5a9df">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp_MComposition_NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstBtnDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstBtnDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d8ea48ea81e3b0b9d70a93e017d32cf">
                  <SHORT-NAME>NrwroadFwdDstL_MComposition_NrwroadFwdDstL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ff6838760b10399fb5e3c4684212f60a">
                  <SHORT-NAME>NrwroadFwdDstR_MComposition_NrwroadFwdDstR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5152e3f32b063f58bf7457cbfd94f025">
                  <SHORT-NAME>NrwroadFwdDstTostDsp_MComposition_NrwroadFwdDstTostDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstTostDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdDstTostDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a65a4f516195347d8abdd51fb84a3edc">
                  <SHORT-NAME>NrwroadFwdReDst_MComposition_NrwroadFwdReDst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdReDst</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdReDst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="97002401d86d350bacfbc1aba3452dcb">
                  <SHORT-NAME>NrwroadFwdReq_MComposition_NrwroadFwdReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89581062c70f301fa107f1e7bad70393">
                  <SHORT-NAME>NrwroadFwdSta_MComposition_NrwroadFwdSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdSta</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9c5d51f9064e39b6b84dd5ff9cdaa97a">
                  <SHORT-NAME>NrwroadFwdSwSts_MComposition_NrwroadFwdSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadFwdSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="917a8014dd2a36c6acc346f30152e1e9">
                  <SHORT-NAME>NrwroadsltReq_MComposition_NrwroadsltReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadsltReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadsltReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b37dff738e993dbda616e5e1fd657e2d">
                  <SHORT-NAME>NrwroadsltSta_MComposition_NrwroadsltSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadsltSta</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/NrwroadsltSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="625e899d3123329fbc9bfb6c99062283">
                  <SHORT-NAME>OnBdChrgrOptAltPwr_MComposition_OnBdChrgrOptAltPwr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OnBdChrgrOptAltPwr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OnBdChrgrOptAltPwr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="97d787a89c263fcbb793cf7d4886eb51">
                  <SHORT-NAME>OtsdAirTemCrValMsk_MComposition_OtsdAirTemCrValMsk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrValMsk</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrValMsk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0ff791a825f3e9b81e5dad53af45df3">
                  <SHORT-NAME>OtsdAirTemCrValV_MComposition_OtsdAirTemCrValV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrValV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrValV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="049256be3ae83fdeb58043950740af47">
                  <SHORT-NAME>OtsdAirTemCrVal_MComposition_OtsdAirTemCrVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/OtsdAirTemCrVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4f103dd371183a0da09035c9a7b081f9">
                  <SHORT-NAME>PDCSysSts_MComposition_PDCSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PDCSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PDCSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="07db9d1e942539a38f2f6c3bdd89b10b">
                  <SHORT-NAME>PDSysKeyPsAvlbl_MComposition_PDSysKeyPsAvlbl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PDSysKeyPsAvlbl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PDSysKeyPsAvlbl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7029a85913693186972c7d220206ecb2">
                  <SHORT-NAME>PEBSts_MComposition_PEBSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="41849b3ba7f132dcbcbbe1b3003e6561">
                  <SHORT-NAME>PEBSwReq_MComposition_PEBSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2fa6f996087d32b6a017493af2679ea5">
                  <SHORT-NAME>PEBSwResp_MComposition_PEBSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="64d050ded60e317ca4e96a8d4c624d4f">
                  <SHORT-NAME>PEBWarngReq_MComposition_PEBWarngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBWarngReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEBWarngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="714695cf53bf39a583b4f84b36677109">
                  <SHORT-NAME>PEU_10ms_Group25_MComposition_PEU_10ms_Group25</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEU_10ms_Group25</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PEU_10ms_Group25</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cb80eb2485c035b79fbda966c38829d1">
                  <SHORT-NAME>PICU_10ms_Group03_MComposition_PICU_10ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_10ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_10ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="53165d4f950c3d419fc18b02113770df">
                  <SHORT-NAME>PICU_10ms_Group23_MComposition_PICU_10ms_Group23</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_10ms_Group23</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_10ms_Group23</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b13376acc7413410a9f115669762d988">
                  <SHORT-NAME>PICU_20ms_Group11_MComposition_PICU_20ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_20ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_20ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1ac770dc05c532eba66182edc575fbe3">
                  <SHORT-NAME>PICU_PTAvlbly_MComposition_PICU_PTAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_PTAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PICU_PTAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b8a2b5ae63f939d8885e3a30e7a467b3">
                  <SHORT-NAME>ParkngDirAvlSts_MComposition_ParkngDirAvlSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirAvlSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirAvlSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d9071c090b713a159642e04bbfdf6857">
                  <SHORT-NAME>ParkngDirSwResp_MComposition_ParkngDirSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="790836cd2bab3e858db3e2fcea5325ec">
                  <SHORT-NAME>ParkngDirSw_MComposition_ParkngDirSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirSw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngDirSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce3b77173bb5363498e7eb10d668656d">
                  <SHORT-NAME>ParkngEndDis_MComposition_ParkngEndDis</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngEndDis</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngEndDis</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa1c92b5a26a3b5a91f00dc63bca9539">
                  <SHORT-NAME>ParkngInPrgs_MComposition_ParkngInPrgs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngInPrgs</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngInPrgs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="390ea2f0bfa43462bafe5eca1c7049da">
                  <SHORT-NAME>ParkngNCPAvlSts_MComposition_ParkngNCPAvlSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngNCPAvlSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngNCPAvlSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ad21151e3b653c40b64adb9844333dd0">
                  <SHORT-NAME>ParkngOutBkCrsSts_MComposition_ParkngOutBkCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de83e7365daf34b593ba25e1035bd70d">
                  <SHORT-NAME>ParkngOutBkLCrsSts_MComposition_ParkngOutBkLCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkLCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkLCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="98e5025a40e63890beba11a7cf92781c">
                  <SHORT-NAME>ParkngOutBkRCrsSts_MComposition_ParkngOutBkRCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkRCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutBkRCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b4609c6feb43393a95e77325635b0558">
                  <SHORT-NAME>ParkngOutDircnSelResult_MComposition_ParkngOutDircnSelResult</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutDircnSelResult</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutDircnSelResult</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4467a5ec46f13d548905b70abd70cbff">
                  <SHORT-NAME>ParkngOutFLCrsSts_MComposition_ParkngOutFLCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFLCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFLCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="baa1653266b832949f931b69e178e0d2">
                  <SHORT-NAME>ParkngOutFLParllSts_MComposition_ParkngOutFLParllSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFLParllSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFLParllSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8bb6347a587c36759c7a957c027bb326">
                  <SHORT-NAME>ParkngOutFRCrsSts_MComposition_ParkngOutFRCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFRCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFRCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="68ec027e1c7335f8bc9a0935ce7a51ce">
                  <SHORT-NAME>ParkngOutFRParllSts_MComposition_ParkngOutFRParllSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFRParllSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFRParllSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e6ce5338197237d3ae938b71be5a0714">
                  <SHORT-NAME>ParkngOutFrtCrsSts_MComposition_ParkngOutFrtCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFrtCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngOutFrtCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="99d1df2f08553bff82211b88e3575d1a">
                  <SHORT-NAME>ParkngSlotFindSts_MComposition_ParkngSlotFindSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngSlotFindSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngSlotFindSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9d2123b8ac7c3a91aca30db2a507c4c0">
                  <SHORT-NAME>ParkngSpdSwResp_MComposition_ParkngSpdSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngSpdSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ParkngSpdSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="787fff9ed5363df99589863f9bca3217">
                  <SHORT-NAME>PilotSysADASFltSts_MComposition_PilotSysADASFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysADASFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysADASFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a23663aaad8234d082a0e56de984d042">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts_MComposition_PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrF1FltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrF1FltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="70d847ff77573ddbaa086671485d97be">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts_MComposition_PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrF3FltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrF3FltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c77ffc1142cb37a28b18d7d5b5e497fa">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts_MComposition_PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrFLSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrFLSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93690eaa0b053807a615c4258f2ee910">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts_MComposition_PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrFRSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrFRSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="abe52085cff83f049c9420a2b31fb1ce">
                  <SHORT-NAME>PilotSysAVCamrRFltSts_MComposition_PilotSysAVCamrRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="375b6e12d9933d51b6c1a5c5f2398b00">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts_MComposition_PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRLSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRLSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="efab3ab42a5434deb2a31e59e3c68915">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts_MComposition_PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRRSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysAVCamrRRSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eee6b889e1c93571aa0993cde0b38e71">
                  <SHORT-NAME>PilotSysFDRFltSts_MComposition_PilotSysFDRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysFDRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysFDRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="858ec837f2a337ef81f3c16b5f863a8f">
                  <SHORT-NAME>PilotSysFLIDARFltSts_MComposition_PilotSysFLIDARFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysFLIDARFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysFLIDARFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7f1bffea79043e3baecdc0e9250c7c03">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts_MComposition_PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrFFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrFFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="643726cfe1863f6996fe9c1b53f6a1cc">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts_MComposition_PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrLHFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrLHFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="478898fd97c0344db06b02fd4e5114a2">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts_MComposition_PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e36724a778dc3c6ca940bb88ff8cdb6c">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts_MComposition_PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrRHFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysHDAVMCamrRHFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="202ea73229d23a71af5c64d461704c45">
                  <SHORT-NAME>PilotSysLFSDAFltSts_MComposition_PilotSysLFSDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysLFSDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysLFSDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a5e2fcf28183a46aa1da2a24c1f1274">
                  <SHORT-NAME>PilotSysLHRDAFltSts_MComposition_PilotSysLHRDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysLHRDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysLHRDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6a6e0f96dd763dd2812442c539d5d68d">
                  <SHORT-NAME>PilotSysMsg_MComposition_PilotSysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b990bc9a0a6430859bbc96fd8cbbf86d">
                  <SHORT-NAME>PilotSysRFSDAFltSts_MComposition_PilotSysRFSDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysRFSDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysRFSDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bbb762830f1e38549cacc9cdaffe1a96">
                  <SHORT-NAME>PilotSysRHRDAFltSts_MComposition_PilotSysRHRDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysRHRDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysRHRDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="51f68feb0de6304fa7128271c9fc548d">
                  <SHORT-NAME>PilotSysUSSFltSts_MComposition_PilotSysUSSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysUSSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PilotSysUSSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="91d5a772278e3b419175f403dd6f70ec">
                  <SHORT-NAME>PosALCFailed_MComposition_PosALCFailed</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PosALCFailed</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PosALCFailed</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8b4d66bac9a73b9f9788367701a8465a">
                  <SHORT-NAME>PositionAttitudeStatus_MComposition_PositionAttitudeStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PositionAttitudeStatus</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PositionAttitudeStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f39fca728739309bbb566c5e7ef9e821">
                  <SHORT-NAME>PrvOutSts_MComposition_PrvOutSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PrvOutSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PrvOutSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0980b5e8bd96399a97ec4d6f655b6460">
                  <SHORT-NAME>PwrDMd_enum_MComposition_PwrDMd_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PwrDMd_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PwrDMd_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a9ef478000143ad1b0f63ff872fe5a1a">
                  <SHORT-NAME>PwrReq_flg_MComposition_PwrReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PwrReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/PwrReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4fe88a0e1d94385ea151dc420f884530">
                  <SHORT-NAME>RAAlrWorDis_MComposition_RAAlrWorDis</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RAAlrWorDis</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RAAlrWorDis</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a4623af49d503c268e7713057e0e9f94">
                  <SHORT-NAME>RACtlReq_MComposition_RACtlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RACtlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RACtlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3b395cc78283cc4a2aad77dd010c239">
                  <SHORT-NAME>RADSSwSts_MComposition_RADSSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RADSSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RADSSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="14b1f5548acb3a2881cdd4af6b100d54">
                  <SHORT-NAME>RASysSts_MComposition_RASysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RASysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RASysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e80c18b3d943eaf8d0ae85a4124f02e">
                  <SHORT-NAME>RCTSysSelReq_MComposition_RCTSysSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RCTSysSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RCTSysSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f33522b9329336109cb4bb32c14fa022">
                  <SHORT-NAME>RCWSelReq_MComposition_RCWSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RCWSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RCWSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cc2a23c0eaa7319c9184d216268168d1">
                  <SHORT-NAME>RDASwReq_MComposition_RDASwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RDASwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RDASwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d787bd6f373336a5a4901f4af8f7478b">
                  <SHORT-NAME>RFCTWrnng_ADAS_MComposition_RFCTWrnng_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFCTWrnng_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFCTWrnng_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dc10aeb1da0b3311b8a06df218c39295">
                  <SHORT-NAME>RFCTWrnng_MComposition_RFCTWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFCTWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFCTWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9fd12c0ee3353618ae03eff9129626a6">
                  <SHORT-NAME>RFSDA_20ms_Group02_MComposition_RFSDA_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RFSDA_20ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RFSDA_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="361d388c98783093a10eae21b075ebfd">
                  <SHORT-NAME>RHRDA_50ms_Group04_MComposition_RHRDA_50ms_Group04</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHRDA_50ms_Group04</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHRDA_50ms_Group04</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f2b6e1e3be0f3f31a4af84396c543b30">
                  <SHORT-NAME>RHZCUAvlbly_MComposition_RHZCUAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCUAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCUAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3bd8ae685ba335d84c634164f80dea9">
                  <SHORT-NAME>RHZCU_100ms_Group10_MComposition_RHZCU_100ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_100ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_100ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a0d2e5c55ef33acafce367c7e44d5bf">
                  <SHORT-NAME>RHZCU_50ms_Group01_MComposition_RHZCU_50ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_50ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_50ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fe5438b7d8ab39fcb02ab44099eb18b5">
                  <SHORT-NAME>RHZCU_50ms_Group27_MComposition_RHZCU_50ms_Group27</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCU_50ms_Group27</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCU_50ms_Group27</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f0f85dca0de433e89c8d56c3d1b97700">
                  <SHORT-NAME>RHZCUeFs1Sts_MComposition_RHZCUeFs1Sts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RHZCUeFs1Sts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RHZCUeFs1Sts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89509995ac6f39e2b0e37bf5229bafa8">
                  <SHORT-NAME>RLObsRng_MComposition_RLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a02e4136f7163bbda5506f37cff2ff63">
                  <SHORT-NAME>RLSObsRng_MComposition_RLSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="72d8ec89bdbb3cccbc3543c66f110737">
                  <SHORT-NAME>RLSUSSSts_MComposition_RLSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ba368c7f2423d4c8f16311d2e187b33">
                  <SHORT-NAME>RLSideObsRng_MComposition_RLSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8ebc3f9ba6cb32a1baa6fbbdee136205">
                  <SHORT-NAME>RLTirePrsV_MComposition_RLTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a291243af2138228f3489cf86b183ec">
                  <SHORT-NAME>RLTirePrs_MComposition_RLTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="440c1c83f35035c996e8a7bac1022aab">
                  <SHORT-NAME>RLTireSts_MComposition_RLTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="be6b82859be637ee8b21ff1d4756daf0">
                  <SHORT-NAME>RLTireTemV_MComposition_RLTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="96f0e0cd82873533a207de5b62a41eb9">
                  <SHORT-NAME>RLTireTem_MComposition_RLTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bf086dc2471e31fbb7c4ac4d1558cc95">
                  <SHORT-NAME>RLUSSSts_MComposition_RLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d8bb214624bf37878bfd173d614860ab">
                  <SHORT-NAME>RMLUSSSts_MComposition_RMLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RMLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RMLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7eb72f13990f3030a0b090b130ca6e2b">
                  <SHORT-NAME>RMRUSSSts_MComposition_RMRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RMRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RMRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8dabe6124c6e3cbca03b63abc8b10b36">
                  <SHORT-NAME>RPShockDistL_MComposition_RPShockDistL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RPShockDistL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RPShockDistL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="314987a883fc3a7899e96230be20e783">
                  <SHORT-NAME>RPShockDistR_MComposition_RPShockDistR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RPShockDistR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RPShockDistR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="00ad4ad061613b5c939d16be61f69e40">
                  <SHORT-NAME>RRObsRng_MComposition_RRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3e9f422c164632af888740c987a943b5">
                  <SHORT-NAME>RRSObsRng_MComposition_RRSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ef786f1356f33d8081900b4bc7b73956">
                  <SHORT-NAME>RRSUSSSts_MComposition_RRSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c973449ef0a836af952e85853e41e6aa">
                  <SHORT-NAME>RRSideObsRng_MComposition_RRSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57d38977ffca351c9a29dc583bf0f36b">
                  <SHORT-NAME>RRTirePrsV_MComposition_RRTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d0a5f5d6c36238dc92ed02c49206ebce">
                  <SHORT-NAME>RRTirePrs_MComposition_RRTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d606422fbd633ecaa4cc1633610aac55">
                  <SHORT-NAME>RRTireSts_MComposition_RRTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="148a9bbcfc8737a39e0461dadd78d15c">
                  <SHORT-NAME>RRTireTemV_MComposition_RRTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e39fc4df04d354eaf231c1d168da68f">
                  <SHORT-NAME>RRTireTem_MComposition_RRTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="39c14cffc7ca3b1ebe017defc90bc947">
                  <SHORT-NAME>RRUSSSts_MComposition_RRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b1831d9672ab3400b949d7f82bf642eb">
                  <SHORT-NAME>RZCUIgnDiagSts_MComposition_RZCUIgnDiagSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCUIgnDiagSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCUIgnDiagSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a83901cf55b3ba8befebb2f8091e75b">
                  <SHORT-NAME>RZCUIgnSts_MComposition_RZCUIgnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCUIgnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCUIgnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="945fa946630f352cb06f29e1382fb659">
                  <SHORT-NAME>RZCU_100ms_Group10_MComposition_RZCU_100ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_100ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_100ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6369435265353371bffb981ea869d82a">
                  <SHORT-NAME>RZCU_10ms_Group01_MComposition_RZCU_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c70da40435543fcfa554c0d2fa1b7f64">
                  <SHORT-NAME>RZCU_10ms_Group02_MComposition_RZCU_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7bd8267074623d9784aac1894a7e9322">
                  <SHORT-NAME>RZCU_10ms_Group22_MComposition_RZCU_10ms_Group22</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group22</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group22</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="83e16665f8c3343ea8746127fff0ae20">
                  <SHORT-NAME>RZCU_10ms_Group23_MComposition_RZCU_10ms_Group23</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group23</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group23</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="925d7af325e234b2ac9026a38e011f9d">
                  <SHORT-NAME>RZCU_10ms_Group24_MComposition_RZCU_10ms_Group24</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group24</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group24</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="73ba541cc17a347ca34ca64a999ce157">
                  <SHORT-NAME>RZCU_10ms_Group90_MComposition_RZCU_10ms_Group90</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_10ms_Group90</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group90</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0399ab60062036f689fc50a4954b20e8">
                  <SHORT-NAME>RZCU_20ms_Group06_MComposition_RZCU_20ms_Group06</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_20ms_Group06</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_20ms_Group06</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="36896c78f6853d20aa1c975d9a89983b">
                  <SHORT-NAME>RZCU_50ms_Group37_MComposition_RZCU_50ms_Group37</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_50ms_Group37</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_50ms_Group37</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6f45f2bbfb0e3f0d9252dd406d77077f">
                  <SHORT-NAME>RZCU_BKBCANFDAvlbly_MComposition_RZCU_BKBCANFDAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_BKBCANFDAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_BKBCANFDAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9c967db0de253629a8ac28066680775c">
                  <SHORT-NAME>RZCU_ZONE_10ms_Group64_MComposition_RZCU_ZONE_10ms_Group64</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RZCU_ZONE_10ms_Group64</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_ZONE_10ms_Group64</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a691ce8f72da32a8875ac9e9ef79b284">
                  <SHORT-NAME>ResetCnt_MComposition_ResetCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ResetCnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ResetCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4fde33c78a933043a1b7838f5aa1da5f">
                  <SHORT-NAME>RoadHeightL_MComposition_RoadHeightL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadHeightL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadHeightL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="170c4c00c54a374c839657d7cd0529c0">
                  <SHORT-NAME>RoadHeightR_MComposition_RoadHeightR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadHeightR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadHeightR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f6ff616496683deb8b1c4a7e184b53b7">
                  <SHORT-NAME>RoadProfileShockConfidenceL1_MComposition_RoadProfileShockConfidenceL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89eafa5cce223b29873487f74428e0c6">
                  <SHORT-NAME>RoadProfileShockConfidenceL2_MComposition_RoadProfileShockConfidenceL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a9b73ad2bca73f30878b94e8af1881fa">
                  <SHORT-NAME>RoadProfileShockConfidenceL3_MComposition_RoadProfileShockConfidenceL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0222e4b8ee153b708726a1b8fb6438e3">
                  <SHORT-NAME>RoadProfileShockConfidenceL_MComposition_RoadProfileShockConfidenceL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3886ac86072e33579d9b2c1607f8406e">
                  <SHORT-NAME>RoadProfileShockConfidenceR1_MComposition_RoadProfileShockConfidenceR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3e5a8e5d744c3a20be69e88bd42fe863">
                  <SHORT-NAME>RoadProfileShockConfidenceR2_MComposition_RoadProfileShockConfidenceR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f017fc0eaf123c57ad6fd68991e9e20d">
                  <SHORT-NAME>RoadProfileShockConfidenceR3_MComposition_RoadProfileShockConfidenceR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a49cccdac3523d90bce7cf3bb9b95a82">
                  <SHORT-NAME>RoadProfileShockConfidenceR_MComposition_RoadProfileShockConfidenceR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockConfidenceR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockConfidenceR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e014d9b7bc00346bb2889c8fd716e2ea">
                  <SHORT-NAME>RoadProfileShockDetectedL1_MComposition_RoadProfileShockDetectedL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78f8ad896f4a33bbb551c353dff9dec3">
                  <SHORT-NAME>RoadProfileShockDetectedL2_MComposition_RoadProfileShockDetectedL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5115c0188c263a6fb42f4f73db3352a9">
                  <SHORT-NAME>RoadProfileShockDetectedL3_MComposition_RoadProfileShockDetectedL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ded10bedcb5e3b3b878aec61ce2cff2a">
                  <SHORT-NAME>RoadProfileShockDetectedL_MComposition_RoadProfileShockDetectedL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="825ba5f4566c3b8faa1d6765d9cd5f63">
                  <SHORT-NAME>RoadProfileShockDetectedR1_MComposition_RoadProfileShockDetectedR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="35dd977446f835aa932455bf0d6168d3">
                  <SHORT-NAME>RoadProfileShockDetectedR2_MComposition_RoadProfileShockDetectedR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ffad7ca03aa32ba8a1f83f3949050c5">
                  <SHORT-NAME>RoadProfileShockDetectedR3_MComposition_RoadProfileShockDetectedR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d06f30cc3f813d2da15d2d737e30445e">
                  <SHORT-NAME>RoadProfileShockDetectedR_MComposition_RoadProfileShockDetectedR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDetectedR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDetectedR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db116103a0763d8da8e3304f439e362a">
                  <SHORT-NAME>RoadProfileShockDistL1_MComposition_RoadProfileShockDistL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="adca2e859a073100b2eda48be894b4d9">
                  <SHORT-NAME>RoadProfileShockDistL2_MComposition_RoadProfileShockDistL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5c8b8fdb83463f0080627c130c3eef66">
                  <SHORT-NAME>RoadProfileShockDistL3_MComposition_RoadProfileShockDistL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="50dccad0bd73302185851dc73514c36a">
                  <SHORT-NAME>RoadProfileShockDistR1_MComposition_RoadProfileShockDistR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a6792b7e75793d77bdcaa9e67a1cee61">
                  <SHORT-NAME>RoadProfileShockDistR2_MComposition_RoadProfileShockDistR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b642623f174d3aad828a5b04f919c305">
                  <SHORT-NAME>RoadProfileShockDistR3_MComposition_RoadProfileShockDistR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockDistR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockDistR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="840356ba075e38918270dd104a367835">
                  <SHORT-NAME>RoadProfileShockHeightL1_MComposition_RoadProfileShockHeightL1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="105c52901e3931aaa034f018f51df47e">
                  <SHORT-NAME>RoadProfileShockHeightL2_MComposition_RoadProfileShockHeightL2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6dcbddd1322f37959699ff01e5bb1de8">
                  <SHORT-NAME>RoadProfileShockHeightL3_MComposition_RoadProfileShockHeightL3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f521e7ae549a3e378ee631caf57006c8">
                  <SHORT-NAME>RoadProfileShockHeightL_MComposition_RoadProfileShockHeightL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4e188d179df538bf858ab786fe8b28b9">
                  <SHORT-NAME>RoadProfileShockHeightR1_MComposition_RoadProfileShockHeightR1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4c9db2b10a17357881de6fa4e65a8985">
                  <SHORT-NAME>RoadProfileShockHeightR2_MComposition_RoadProfileShockHeightR2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="efc129cabcfe368bbe88bce1b262ac41">
                  <SHORT-NAME>RoadProfileShockHeightR3_MComposition_RoadProfileShockHeightR3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8aea5302341e39ff9c5b7ceb5ae65611">
                  <SHORT-NAME>RoadProfileShockHeightR_MComposition_RoadProfileShockHeightR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockHeightR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockHeightR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="299b02d33de53573b0d56694c8024779">
                  <SHORT-NAME>RoadProfileShockLevelL_MComposition_RoadProfileShockLevelL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockLevelL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockLevelL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="55c75562a81d39269655f867546c5a1b">
                  <SHORT-NAME>RoadProfileShockLevelR_MComposition_RoadProfileShockLevelR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RoadProfileShockLevelR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RoadProfileShockLevelR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c8cffd002213972b01c76de1d15331e">
                  <SHORT-NAME>Rolloff2Min_flg_MComposition_Rolloff2Min_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Rolloff2Min_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/Rolloff2Min_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f9d5265c7f3c3bb9a9b3621b7569309f">
                  <SHORT-NAME>RolloffHld_flg_MComposition_RolloffHld_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RolloffHld_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RolloffHld_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="681cb437e28a3d6980391c7c096c4ec1">
                  <SHORT-NAME>RrMidLObsRng_MComposition_RrMidLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrMidLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrMidLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0dd077e3a8a33538b32ff57202e62229">
                  <SHORT-NAME>RrMidRObsRng_MComposition_RrMidRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrMidRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrMidRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d522ef64e683df3a193f40e4b92b90e">
                  <SHORT-NAME>RrObsDist_MComposition_RrObsDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrObsDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrObsDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c3a18752cf89310f89152b0a63424959">
                  <SHORT-NAME>RrPDCAudWrnng_MComposition_RrPDCAudWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrPDCAudWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrPDCAudWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c5c9c75803ed3baeba843b14aa879327">
                  <SHORT-NAME>RrTireStdPrs_MComposition_RrTireStdPrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RrTireStdPrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RrTireStdPrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="234abef38f2a35daba35dd2da52d6a3b">
                  <SHORT-NAME>RstrFctryDeftsReq_MComposition_RstrFctryDeftsReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/RstrFctryDeftsReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RstrFctryDeftsReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2bb0aae6c0a4328389f639cca3924c66">
                  <SHORT-NAME>SDMAvlbly_MComposition_SDMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2d73eaf1a0f335eca681481b97d9224e">
                  <SHORT-NAME>SDM_20ms_Group01_MComposition_SDM_20ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7ca0405cff430b6a9c0665c15bd98fe">
                  <SHORT-NAME>SDM_20ms_Group02_MComposition_SDM_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db0d3d8209a133cfa410a33d92672638">
                  <SHORT-NAME>SDM_20ms_Group03_MComposition_SDM_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SDM_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e5b104f8755134b38a00a112817802c3">
                  <SHORT-NAME>SLIFAudWrnng_IPD_MComposition_SLIFAudWrnng_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFAudWrnng_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFAudWrnng_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3babb8d70d12399b90ab444cbe71b896">
                  <SHORT-NAME>SLIFSts_IPD_MComposition_SLIFSts_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFSts_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFSts_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ef7867d524e43bd4b7497d7d99e58fd1">
                  <SHORT-NAME>SLIFSysFltSts_MComposition_SLIFSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e296f17d503a3e65af4e94bbdf5350fa">
                  <SHORT-NAME>SLIFUpdtIndReq_MComposition_SLIFUpdtIndReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtIndReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtIndReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd788613d81936a4b8a40760e9c2e9ad">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD_MComposition_SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtIndResp_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtIndResp_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7597540f357a3188a21fde4318b31102">
                  <SHORT-NAME>SLIFUpdtInd_IPD_MComposition_SLIFUpdtInd_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFUpdtInd_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFUpdtInd_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5b187b503eaa3f11aa2098ae52f6c50e">
                  <SHORT-NAME>SLIFWrnngMdReq_MComposition_SLIFWrnngMdReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFWrnngMdReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFWrnngMdReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="40600d8fa3553691933794ab2de3827f">
                  <SHORT-NAME>SLIFWrnngMdResp_MComposition_SLIFWrnngMdResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SLIFWrnngMdResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SLIFWrnngMdResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ab4c7f7a5abf37558968261a197d99c1">
                  <SHORT-NAME>SOCLowPwrDwn_flg_MComposition_SOCLowPwrDwn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCLowPwrDwn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCLowPwrDwn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7f627a3c0d5b35cfb6fd324ed203ace1">
                  <SHORT-NAME>SOCLvl_enum_MComposition_SOCLvl_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCLvl_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCLvl_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4f835dd0e04c341ba2ab39befaf8fd1d">
                  <SHORT-NAME>SOCMd_enum_MComposition_SOCMd_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SOCMd_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SOCMd_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e10f8cad5693b1fa99368e273e4234c">
                  <SHORT-NAME>SatAz10_MComposition_SatAz10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d34423ec9a4d3616acb8422511c2b9bb">
                  <SHORT-NAME>SatAz11_MComposition_SatAz11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d9a9d6b29c0c3e2085aa00d58344c043">
                  <SHORT-NAME>SatAz12_MComposition_SatAz12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e141317952db3a3093682edb14788f81">
                  <SHORT-NAME>SatAz13_MComposition_SatAz13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="971f0200ba2330ce8c28bcc6ed65f983">
                  <SHORT-NAME>SatAz14_MComposition_SatAz14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="718a8df4386d38c78057c00ca3ea8025">
                  <SHORT-NAME>SatAz15_MComposition_SatAz15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c51920b9d543cf3b25d3c81d354615b">
                  <SHORT-NAME>SatAz16_MComposition_SatAz16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d66f09c7a8b23574ac013144e8668ed8">
                  <SHORT-NAME>SatAz17_MComposition_SatAz17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e52c53c08673fc990ca26d5d93d6057">
                  <SHORT-NAME>SatAz18_MComposition_SatAz18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9639cc1d1e9d325e8dd05bc4589389fe">
                  <SHORT-NAME>SatAz19_MComposition_SatAz19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="19e3bbff6f60354fb7737c9f524f5bdf">
                  <SHORT-NAME>SatAz1_MComposition_SatAz1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="18663356f4b931909f07c67a1519e8e9">
                  <SHORT-NAME>SatAz20_MComposition_SatAz20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d67c44ae15dc387c80e377f74eb2fbe0">
                  <SHORT-NAME>SatAz2_MComposition_SatAz2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9dbde441f1c34ffb09780e7f5483a8e">
                  <SHORT-NAME>SatAz3_MComposition_SatAz3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9bd4f832f485395aa36ed2bbf754b15b">
                  <SHORT-NAME>SatAz4_MComposition_SatAz4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="801e1be550e531199f5082d137749f72">
                  <SHORT-NAME>SatAz5_MComposition_SatAz5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="233851f58b65386191b27f7a264ca3c2">
                  <SHORT-NAME>SatAz6_MComposition_SatAz6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6a48b29034c234159247a0d7e5948c5b">
                  <SHORT-NAME>SatAz7_MComposition_SatAz7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9260c7e9e9cd39d5a4d43bae824aeb87">
                  <SHORT-NAME>SatAz8_MComposition_SatAz8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8704064561333de79983dd3ecd832ff8">
                  <SHORT-NAME>SatAz9_MComposition_SatAz9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatAz9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatAz9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6432161c491e3710a82718ca81f7cbcc">
                  <SHORT-NAME>SatCNO10_MComposition_SatCNO10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e10b49359833954aac634fbc524d99c">
                  <SHORT-NAME>SatCNO11_MComposition_SatCNO11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a5dd11682638354f8846e49950cb92a5">
                  <SHORT-NAME>SatCNO12_MComposition_SatCNO12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1840f961401d35d7bbeeb5a767f1b31d">
                  <SHORT-NAME>SatCNO13_MComposition_SatCNO13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="552b151972a63a25a12afa824ede883a">
                  <SHORT-NAME>SatCNO14_MComposition_SatCNO14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aa73f420e9ef30f3acab83d800a7babe">
                  <SHORT-NAME>SatCNO15_MComposition_SatCNO15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f233cb49abc631efaea4377e833faaaf">
                  <SHORT-NAME>SatCNO16_MComposition_SatCNO16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d2a52c1e6f193659bd5a524a90d2a646">
                  <SHORT-NAME>SatCNO17_MComposition_SatCNO17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b881f99a7310300ab71cdb463ffd18bb">
                  <SHORT-NAME>SatCNO18_MComposition_SatCNO18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="67c3ddcbb87230ac8dd1bbab3a7c36ba">
                  <SHORT-NAME>SatCNO19_MComposition_SatCNO19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dab704246d253b4e96e2d2ef6e4f27be">
                  <SHORT-NAME>SatCNO1_MComposition_SatCNO1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cc53ac9e62e5369ab4607dc14f2fc34b">
                  <SHORT-NAME>SatCNO20_MComposition_SatCNO20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a97abccd31b23cfc8bd1e028f79be4cd">
                  <SHORT-NAME>SatCNO2_MComposition_SatCNO2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="54f63b7480b13da6bf4455d7cbeaabb5">
                  <SHORT-NAME>SatCNO3_MComposition_SatCNO3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d4dee80e4531342a90eeb1238ec10995">
                  <SHORT-NAME>SatCNO4_MComposition_SatCNO4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b99be3088fea3187b7b596cff44c509f">
                  <SHORT-NAME>SatCNO5_MComposition_SatCNO5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="51b18f18375332328dc6206b476dbf7c">
                  <SHORT-NAME>SatCNO6_MComposition_SatCNO6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7796a41e837630379edec369d85d369e">
                  <SHORT-NAME>SatCNO7_MComposition_SatCNO7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="97621adb1bc4374b928c732f74539840">
                  <SHORT-NAME>SatCNO8_MComposition_SatCNO8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="47bf69c19afb3f38aaa473f735cfb9b8">
                  <SHORT-NAME>SatCNO9_MComposition_SatCNO9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatCNO9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatCNO9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6236b4e2ffe63a6b814e1dd0ac60578c">
                  <SHORT-NAME>SatElv10_MComposition_SatElv10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="01e9f0b42af9315f943084d5ad29afa4">
                  <SHORT-NAME>SatElv11_MComposition_SatElv11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1bbbbc6a114e394f97c81a389bd31ec4">
                  <SHORT-NAME>SatElv12_MComposition_SatElv12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="79a741d9a5753119a3c1b072ca5492ae">
                  <SHORT-NAME>SatElv13_MComposition_SatElv13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="afa861ab1b8d3b9da27da456846b0b1b">
                  <SHORT-NAME>SatElv14_MComposition_SatElv14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d55a7843c331395482aced0e658b14c7">
                  <SHORT-NAME>SatElv15_MComposition_SatElv15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="75a064996d853003b0c518d996255943">
                  <SHORT-NAME>SatElv16_MComposition_SatElv16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f9df639162b939bba1c2b44948a0d5a5">
                  <SHORT-NAME>SatElv17_MComposition_SatElv17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2dcfc69797653b7fba70de4d705d2856">
                  <SHORT-NAME>SatElv18_MComposition_SatElv18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="15529cd4e9c23130b8f3b429401369ec">
                  <SHORT-NAME>SatElv19_MComposition_SatElv19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b8400f0d08333179ac41ee3c02c59e50">
                  <SHORT-NAME>SatElv1_MComposition_SatElv1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="05385c5e193b33a8a97271621798bfe5">
                  <SHORT-NAME>SatElv20_MComposition_SatElv20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="95701ce969323ecbb123c4628b4e9b84">
                  <SHORT-NAME>SatElv2_MComposition_SatElv2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25129f58a95f3037ba6d2f385716eb5e">
                  <SHORT-NAME>SatElv3_MComposition_SatElv3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="11380ae6484a30b79c9b5124dcea2de8">
                  <SHORT-NAME>SatElv4_MComposition_SatElv4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0cdf2a0d174733e8910b64673887f9fe">
                  <SHORT-NAME>SatElv5_MComposition_SatElv5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6f08e627083e3fcfa1e64cc56e10ceab">
                  <SHORT-NAME>SatElv6_MComposition_SatElv6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="740d3ab376ce3ee6be0b568fab713a45">
                  <SHORT-NAME>SatElv7_MComposition_SatElv7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2ad689736de23f8092db73fe2b9656d3">
                  <SHORT-NAME>SatElv8_MComposition_SatElv8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b46f57bc1bd432489925f4a5fc7bea8b">
                  <SHORT-NAME>SatElv9_MComposition_SatElv9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatElv9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatElv9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c55bcdb867835a39d63a5bbeb860a29">
                  <SHORT-NAME>SatID10_MComposition_SatID10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="94bbb8ce6ac733fc8ea74a385f2d5fef">
                  <SHORT-NAME>SatID11_MComposition_SatID11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="da3cdde79bf539f2919dab33e7881506">
                  <SHORT-NAME>SatID12_MComposition_SatID12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eeaf9e6b0be330d9aea1f7fc12d9f1bb">
                  <SHORT-NAME>SatID13_MComposition_SatID13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b0d31b2554043de18f5f72c56e7bb0a7">
                  <SHORT-NAME>SatID14_MComposition_SatID14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID14</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b855503605443347bb93e6db24c15b0d">
                  <SHORT-NAME>SatID15_MComposition_SatID15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aaa56b990117342a863ee62d99838c4e">
                  <SHORT-NAME>SatID16_MComposition_SatID16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5743a3017cfc36c082854240bacc1b85">
                  <SHORT-NAME>SatID17_MComposition_SatID17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c8a14a0e3c2836e09a3b295b6e6bf78b">
                  <SHORT-NAME>SatID18_MComposition_SatID18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0594e0686d9f395aa8805ec6be684e62">
                  <SHORT-NAME>SatID19_MComposition_SatID19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ee61e1cb20ae3c229cddd93e2cca4e19">
                  <SHORT-NAME>SatID1_MComposition_SatID1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID1</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87bd897aa984399396b95ce4c6626119">
                  <SHORT-NAME>SatID20_MComposition_SatID20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="29325342a26f3c55810abf4bf87ae440">
                  <SHORT-NAME>SatID2_MComposition_SatID2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID2</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a8d39a10ddf368e8b99ecb8a26fe775">
                  <SHORT-NAME>SatID3_MComposition_SatID3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID3</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="082bc10a4cce32d38ffe085747ac6c4e">
                  <SHORT-NAME>SatID4_MComposition_SatID4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID4</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2aff71f5214b3e86841f37a5267cd648">
                  <SHORT-NAME>SatID5_MComposition_SatID5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID5</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5b3a637fbcca3097a28aaa224c1695b6">
                  <SHORT-NAME>SatID6_MComposition_SatID6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID6</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f587a2dbb40d3563a0a9816db08b1f98">
                  <SHORT-NAME>SatID7_MComposition_SatID7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID7</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="50170b8ad6e634c1bb98c23da2ec845d">
                  <SHORT-NAME>SatID8_MComposition_SatID8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID8</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b44eed9809737fcb019f6ba819dc53a">
                  <SHORT-NAME>SatID9_MComposition_SatID9</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatID9</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatID9</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a54db3025bef3179acdacbea6d80ff66">
                  <SHORT-NAME>SatNoInAttitudeRTK_MComposition_SatNoInAttitudeRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNoInAttitudeRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNoInAttitudeRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="144fddf8799b3f5e84f1d1435f5f927f">
                  <SHORT-NAME>SatNoInPositionRTK_MComposition_SatNoInPositionRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNoInPositionRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNoInPositionRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c4bb8c86460b34e3b8c40b2c8dddc23b">
                  <SHORT-NAME>SatNum_MComposition_SatNum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SatNum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SatNum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8de0e4d27ac2337a8ee92f2014f0a409">
                  <SHORT-NAME>SeatOccptnNum_MComposition_SeatOccptnNum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SeatOccptnNum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SeatOccptnNum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="deb9c301c95f30b89e9558873d9efa74">
                  <SHORT-NAME>ShftSeqStat_enum_MComposition_ShftSeqStat_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ShftSeqStat_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ShftSeqStat_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f12d4a81890a3c888e9113154ff94f56">
                  <SHORT-NAME>SideLghtSts_MComposition_SideLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SideLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SideLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f9356b834e73331fbd67838662c0a660">
                  <SHORT-NAME>SpdAstCndStsCamr_MComposition_SpdAstCndStsCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdAstCndStsCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdAstCndStsCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6518c5c035af392fb1704c1a4b310311">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD_MComposition_SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdAstSysTrgtSpd_IPD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdAstSysTrgtSpd_IPD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f8bb0b07a1b3e6ca253dee97c9f3684">
                  <SHORT-NAME>SpdLimitManualSts_MComposition_SpdLimitManualSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLimitManualSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLimitManualSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="16099b0d956a3efd83b4248f6bbf12e1">
                  <SHORT-NAME>SpdLmtMdMsgReq_MComposition_SpdLmtMdMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtMdMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtMdMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d818714bf603d5a9bc1e959ed3dc47c">
                  <SHORT-NAME>SpdLmtMdResp_MComposition_SpdLmtMdResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtMdResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtMdResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2fe7b38ed2ce30fdbc810fc71041d6f0">
                  <SHORT-NAME>SpdLmtNav_MComposition_SpdLmtNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="17c2e2a382e8313ea06d249621a4edc7">
                  <SHORT-NAME>SpdLmtOfstSetNumReq_MComposition_SpdLmtOfstSetNumReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetNumReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetNumReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f9bb6913e5c39109dd7f739f68fba57">
                  <SHORT-NAME>SpdLmtOfstSetNumResp_MComposition_SpdLmtOfstSetNumResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetNumResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetNumResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f92cb243db1738c0bad3434129cf7f51">
                  <SHORT-NAME>SpdLmtOfstSetPercReq_MComposition_SpdLmtOfstSetPercReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetPercReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetPercReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e34f927356eb3537a544926b80229911">
                  <SHORT-NAME>SpdLmtOfstSetPercResp_MComposition_SpdLmtOfstSetPercResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetPercResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetPercResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6f1683871aa23cc8a6174de31b936e99">
                  <SHORT-NAME>SpdLmtOfstSetReq_MComposition_SpdLmtOfstSetReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="327cace7f94839b3995ddd3bd2d674c8">
                  <SHORT-NAME>SpdLmtOfstSetResp_MComposition_SpdLmtOfstSetResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtOfstSetResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtOfstSetResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="90efdd10f33b3142ad60606c75ea2fee">
                  <SHORT-NAME>SpdLmtPathRngNav_MComposition_SpdLmtPathRngNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpdLmtPathRngNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpdLmtPathRngNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c27b17bef7e33c969ec9cc0df0a58a67">
                  <SHORT-NAME>SpedRegulaModSwReq_MComposition_SpedRegulaModSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpedRegulaModSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpedRegulaModSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2115986b065c3417b052b9e04ef33f14">
                  <SHORT-NAME>SpedRegulaModSwSts_MComposition_SpedRegulaModSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SpedRegulaModSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SpedRegulaModSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f3c7eafe0ec833d7944aa907191fd6ce">
                  <SHORT-NAME>StrtTypAvail_enum_MComposition_StrtTypAvail_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/StrtTypAvail_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/StrtTypAvail_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e1187a8f2c0f3265a8f57b69ea389299">
                  <SHORT-NAME>SvGroup_MComposition_SvGroup</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/SvGroup</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SvGroup</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34b4eee10a343796a2015e2cc358f4ca">
                  <SHORT-NAME>TASSAMTqSplt_Nm_MComposition_TASSAMTqSplt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TASSAMTqSplt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TASSAMTqSplt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a29ad646d73327e99f512583e9bd518">
                  <SHORT-NAME>TASTMTqSplt_Nm_MComposition_TASTMTqSplt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TASTMTqSplt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TASTMTqSplt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="68e2b6c7ce43332ab219b6cbdc8d8fb4">
                  <SHORT-NAME>TCM_020ms_PDU18_MComposition_TCM_020ms_PDU18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_020ms_PDU18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_020ms_PDU18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="483b63fadc8636e0aabdfb082702afaf">
                  <SHORT-NAME>TCM_025ms_Group02_MComposition_TCM_025ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_025ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_025ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ddcb062b181534608eb51cf71a175fee">
                  <SHORT-NAME>TCM_025ms_PDU20_MComposition_TCM_025ms_PDU20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_025ms_PDU20</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_025ms_PDU20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25485c37a09f32e6b7527d39788333cc">
                  <SHORT-NAME>TCM_PTCAN_FrP05_MComposition_TCM_PTCAN_FrP05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCM_PTCAN_FrP05</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_PTCAN_FrP05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="417531d69f693da08e2835c602de3270">
                  <SHORT-NAME>TCUIntvSAMTq_Nm_MComposition_TCUIntvSAMTq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUIntvSAMTq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUIntvSAMTq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89dfdc98f11032b3929b15a441ba6a70">
                  <SHORT-NAME>TCUIntvTMTq_Nm_MComposition_TCUIntvTMTq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUIntvTMTq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUIntvTMTq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="861bdc92a5fa3e8dbe961acb9b72c42a">
                  <SHORT-NAME>TCUOpSt_enum_MComposition_TCUOpSt_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TCUOpSt_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCUOpSt_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1821216295e035e787f9958339506620">
                  <SHORT-NAME>TDMAvlbly_MComposition_TDMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TDMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TDMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7320f052c3443a348c7b115217c31bc5">
                  <SHORT-NAME>TDM_200ms_Group01_MComposition_TDM_200ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TDM_200ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TDM_200ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a736e10b8dab3916a14004b78a3033da">
                  <SHORT-NAME>TJAICAMsgReq_MComposition_TJAICAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TJAICAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TJAICAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="70da0bfb18ec3aabb3f921e6460060e1">
                  <SHORT-NAME>TLRMdSwDspCmd_MComposition_TLRMdSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMdSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMdSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0ec11d1f300c36df895a129f0601f1be">
                  <SHORT-NAME>TLRMdSwReq_MComposition_TLRMdSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMdSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMdSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c4435c7e716368ea96654b519f3d5b8">
                  <SHORT-NAME>TLRMsgReq_MComposition_TLRMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1acafb32a4fe39a1a6ab4943339b1799">
                  <SHORT-NAME>TLRSysSts_MComposition_TLRSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e5fccebaf083c01af5101d91d2083bc">
                  <SHORT-NAME>TLRWarning_MComposition_TLRWarning</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TLRWarning</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TLRWarning</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="96692f6ffcef3df08da2ef873499aa71">
                  <SHORT-NAME>TPMSBtmNosRSSI_MComposition_TPMSBtmNosRSSI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSBtmNosRSSI</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSBtmNosRSSI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="542525bbf2823b659b566de4c1973c90">
                  <SHORT-NAME>TPMSSnsrIDLoctn_MComposition_TPMSSnsrIDLoctn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrIDLoctn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrIDLoctn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cab07384d36a3e04a92e111ef86d199d">
                  <SHORT-NAME>TPMSSnsrID_MComposition_TPMSSnsrID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrID</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="69eaa56828c03627975c5729806a1b64">
                  <SHORT-NAME>TPMSSnsrRSSI_MComposition_TPMSSnsrRSSI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRSSI</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRSSI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="76e074136b6a3da28eb41b4ac71fef4a">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn_MComposition_TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRdoFrqcCtrLoctn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRdoFrqcCtrLoctn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ad7067f2567a30c28c6416ac3be272ad">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr_MComposition_TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSSnsrRdoFrqcCtr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSSnsrRdoFrqcCtr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7889f5e74803d03b40ad5f101130f0d">
                  <SHORT-NAME>TPMSWntrMdA_MComposition_TPMSWntrMdA</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TPMSWntrMdA</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TPMSWntrMdA</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a37f549f1782323396dc33dd0c921e48">
                  <SHORT-NAME>TQRTMTqReq_N_MComposition_TQRTMTqReq_N</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TQRTMTqReq_N</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TQRTMTqReq_N</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0f04251db7283a88bddb9d2b7a4dbb70">
                  <SHORT-NAME>TRCEMTqReq_Nm_MComposition_TRCEMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TRCEMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TRCEMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2c428f3ffc2e3f2e83217ae5d88acd41">
                  <SHORT-NAME>TRCTqDmdSTC_Nm_MComposition_TRCTqDmdSTC_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TRCTqDmdSTC_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TRCTqDmdSTC_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="42f63c79f5ee3c458e09c86936f694b5">
                  <SHORT-NAME>TSRSts_MComposition_TSRSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="481d45fa3bcb3e66814544dc6361f5b2">
                  <SHORT-NAME>TSRSwReqResp_MComposition_TSRSwReqResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSwReqResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSwReqResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6b0a11b1f9273cf4b6154f95b0831dfd">
                  <SHORT-NAME>TSRSwReq_MComposition_TSRSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d6378cc614d3d90bb2621c724063ac0">
                  <SHORT-NAME>TSRTrgtBanSign_MComposition_TSRTrgtBanSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRTrgtBanSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRTrgtBanSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="283404c8129833848aa0738da648ec76">
                  <SHORT-NAME>TSRTrgtWarnSign_MComposition_TSRTrgtWarnSign</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TSRTrgtWarnSign</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TSRTrgtWarnSign</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="04fcb9d3875f3cb5b4906c936fbc1e36">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm_MComposition_TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TZXEMMaxTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TZXEMMaxTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bebf55d70b493d46b604701180649908">
                  <SHORT-NAME>TZXEMTqReq_Nm_MComposition_TZXEMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TZXEMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TZXEMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1fe4ef91bb9b39889d9006593927cbd7">
                  <SHORT-NAME>TemSnsrHdwrFltPrst_MComposition_TemSnsrHdwrFltPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TemSnsrHdwrFltPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TemSnsrHdwrFltPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="08c5a0ef18583336afaf8e7601c9282e">
                  <SHORT-NAME>TgtParkingFavorite_MComposition_TgtParkingFavorite</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TgtParkingFavorite</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TgtParkingFavorite</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="040815b2bf6f30e0aa31932d5c52aecd">
                  <SHORT-NAME>ToEPSMsgChlg_MComposition_ToEPSMsgChlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ToEPSMsgChlg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ToEPSMsgChlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ee488e37b6d438528775896af706d8df">
                  <SHORT-NAME>TqCtrlStat_enum_MComposition_TqCtrlStat_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TqCtrlStat_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TqCtrlStat_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="433aeb0d6b48315ea5f6ea3f215c5f01">
                  <SHORT-NAME>TrdtnKeyBtnSts_MComposition_TrdtnKeyBtnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnKeyBtnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnKeyBtnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="461ea2d9853c385fb415650b38dad3c4">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts_MComposition_TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyFindCarSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyFindCarSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="03aa17f857e4341fbfb0ac3fa92af239">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts_MComposition_TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyLckSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyLckSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="69c537900edf36bc954fe735c3be3825">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts_MComposition_TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyLdspcSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyLdspcSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1717eef718a6352496bd43f8c5ccfaca">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts_MComposition_TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrdtnSmrtKyUnlckSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrdtnSmrtKyUnlckSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="789dfce90b23321caa15c0b0c926ebb8">
                  <SHORT-NAME>TrfGreenLghtActn_MComposition_TrfGreenLghtActn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfGreenLghtActn</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfGreenLghtActn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="88653c95690333c3933e9297a4708edc">
                  <SHORT-NAME>TrfcForbidDist_MComposition_TrfcForbidDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcForbidDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TrfcForbidDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b93eaabaaa383b9a8cb6c8b5f058617d">
                  <SHORT-NAME>TrfcInfoSignDist_MComposition_TrfcInfoSignDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/MComposition</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/TrfcInfoSignDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
