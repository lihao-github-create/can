              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group13_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="138033f3ca573f15a11a5a6c55721b67">
              <SHORT-NAME>IAM_ZONE_100ms_Group13_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group13_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8a83d6e1f3803590b29d7461eada29ca">
              <SHORT-NAME>IAM_ZONE_100ms_Group13_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group13_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="55cd6a47a307379aaedb8425989c9faf">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f4b5566d3923e6e9a793d0e8419e9fa">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc126298b45c3089a94ca079bca5f0d6">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bca423c550533062a98efe35e72a8e85">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a38d3b06ef50367d8c54a5a0ceda41d9">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91844047a7623f9790a902774ca85ac6">
              <SHORT-NAME>IAM_ZONE_100ms_Group34_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group34_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b968dc9be9ad3e2492b2594c750c2166">
              <SHORT-NAME>IAM_ZONE_100ms_Group35_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group35_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="510be84bcd2635ce80cf5a4ea6639f13">
              <SHORT-NAME>IAM_ZONE_100ms_Group35_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group35_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="18a4449f04fa3cb287b85af82bbafc7d">
              <SHORT-NAME>IAM_ZONE_100ms_Group35_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group35_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ecb014308cd231d6b2ba488837b8bd68">
              <SHORT-NAME>IAM_ZONE_100ms_Group40_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group40_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69a7db6fb69339d78b6ad0163cb1ba4b">
              <SHORT-NAME>IAM_ZONE_100ms_Group40_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group40_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b0008e202b03b369f697541a3da2a22">
              <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group40_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="03c8002ce6b136dd99cca1b111506a52">
              <SHORT-NAME>IAM_ZONE_100ms_Group40_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group40_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b19d5cb37a31313c85c92d2b631b864b">
              <SHORT-NAME>IAM_ZONE_100ms_Group57_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group57_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b03919f8fb33008b82721c812a01ea8">
              <SHORT-NAME>IAM_ZONE_100ms_Group57_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group57_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b4e53e7aa783374a1e3fe0cd60c27e2">
              <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group57_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a67f815056f03fecbb14605d67206d84">
              <SHORT-NAME>IAM_ZONE_100ms_Group57_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IAM_ZONE_100ms_Group57_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a14026bf4bbe3c7781ff28ca01beea8f">
              <SHORT-NAME>IBSABSlvlResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBSABSlvlResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e21a650f2d8e3247b706bd1b1a2e78fc">
              <SHORT-NAME>IBSAPASysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBSAPASysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59c6509af145318c906a0509ad20c4e1">
              <SHORT-NAME>IBSESPlvlResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBSESPlvlResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fea109a4c2983675a39ea31d78b3cc0e">
              <SHORT-NAME>IBSRespAccToqVal</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBSRespAccToqVal</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f95f2f9962b63e54800b24bf66a800d7">
              <SHORT-NAME>IBSTCSlvlResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBSTCSlvlResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="15c18d902f4734c58079c1c7ddb2d1ae">
              <SHORT-NAME>IBS_100ms_Group15_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2a3e567ff98d333486b9fb7d5dd05085">
              <SHORT-NAME>IBS_100ms_Group15_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f36ab0eb25c3739b53a309d039c8bff">
              <SHORT-NAME>IBS_100ms_Group15_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="01bc94445f9036328c3b6669c5777332">
              <SHORT-NAME>IBS_100ms_Group15_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8aad7e154d2a3254b003351b5e1f779e">
              <SHORT-NAME>IBS_100ms_Group15_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e99e9daeaed138aa88377049c03f2d3e">
              <SHORT-NAME>IBS_100ms_Group15_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93eeaa09e0c13281836d48e9af464fcd">
              <SHORT-NAME>IBS_100ms_Group15_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="34593fef921c3ca88035bd19a60af7f8">
              <SHORT-NAME>IBS_100ms_Group15_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_100ms_Group15_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="50250f858cf43c6887119c3c269fa738">
              <SHORT-NAME>IBS_10ms_Group04_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="120e207a5a043bafa5d188263b1f1f0d">
              <SHORT-NAME>IBS_10ms_Group04_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd7eaa3ac05637ec80c60099b1381ff3">
              <SHORT-NAME>IBS_10ms_Group04_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="24d763a19eca3f91a67010d23b985589">
              <SHORT-NAME>IBS_10ms_Group04_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="43cb57c5b86d312ca48c2b90d1d47900">
              <SHORT-NAME>IBS_10ms_Group04_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b66f3b0b2ca13461822d0f3db0e0addf">
              <SHORT-NAME>IBS_10ms_Group04_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="763479ffafbb35bc9fea6039dff7e87e">
              <SHORT-NAME>IBS_10ms_Group04_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5b3723b1e56939b5bda3d4d2e9f4fb9a">
              <SHORT-NAME>IBS_10ms_Group04_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_10ms_Group04_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba462cee99b83499a9a3e36aa225323f">
              <SHORT-NAME>IBS_20ms_Group07_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group07_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13f0a947644a33a18cb7f5dcff38ee0d">
              <SHORT-NAME>IBS_20ms_Group07_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group07_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79f74ae67de93f8a8058bec219ced682">
              <SHORT-NAME>IBS_20ms_Group08_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group08_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="661aa1a314863fbd88fac69254f4d7b5">
              <SHORT-NAME>IBS_20ms_Group08_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group08_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce10c2d3302239f9bc1cf9b772943abc">
              <SHORT-NAME>IBS_20ms_Group09_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group09_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8cfd57e24697357f8c434f63582b2fc2">
              <SHORT-NAME>IBS_20ms_Group09_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group09_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8573642a1b4a3d4f8757ddcfd11ae301">
              <SHORT-NAME>IBS_20ms_Group09_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group09_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea54826d0a98304c9e6b23f234515029">
              <SHORT-NAME>IBS_20ms_Group10_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group10_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ca06c8a3a1663ad2bd3f5810e0e4f3c6">
              <SHORT-NAME>IBS_20ms_Group10_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group10_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4c0361c8488d39d3bc22de31695d16c2">
              <SHORT-NAME>IBS_20ms_Group10_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group10_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef2ccc0871e33082b647f384dad52759">
              <SHORT-NAME>IBS_20ms_Group10_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group10_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b9a01c7e3d9362c92394b58027eb404">
              <SHORT-NAME>IBS_20ms_Group11_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group11_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="30bc60c800f13589a3cdb1efdbc65df8">
              <SHORT-NAME>IBS_20ms_Group11_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group11_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1867ae8793bd33bdbad5d35280e34e1c">
              <SHORT-NAME>IBS_20ms_Group11_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group11_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96b3d2086bed3196aafa32d2371343ba">
              <SHORT-NAME>IBS_20ms_Group12_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group12_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f1c159a98fe38ba8460eaaf1aa4d8f6">
              <SHORT-NAME>IBS_20ms_Group12_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group12_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d8432e67e163c36b7488269dad35dcf">
              <SHORT-NAME>IBS_20ms_Group12_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group12_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fcf2bce6559c3972bc94e19bb683351b">
              <SHORT-NAME>IBS_20ms_Group12_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group12_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="79633b7856d53a8cb3d1a7585c5e31d3">
              <SHORT-NAME>IBS_20ms_Group13_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group13_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d61ab708818b3b11a0023af48790ec94">
              <SHORT-NAME>IBS_20ms_Group13_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_20ms_Group13_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0d4d6acb4f0434c49f0a1cc1736797b6">
              <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_CHAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d3a611477b533351a1da290ee7a6259c">
              <SHORT-NAME>IBS_NKI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a9514f739707346fb7fb6e154be4f7f5">
              <SHORT-NAME>IBS_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a3b49add796536f085c51393cbb1d364">
              <SHORT-NAME>IBS_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ea1565980e2375c9db1ab032a616d46">
              <SHORT-NAME>IBS_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5acde6b42b3e31dfbb96302e03582b4e">
              <SHORT-NAME>IBS_NM_NOSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="759850ecaa05323799e0be21667cf848">
              <SHORT-NAME>IBS_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="11bae5c47323309a8246b2278828b9e4">
              <SHORT-NAME>IBS_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94a0385a805b33558688e225ee7589a1">
              <SHORT-NAME>IBS_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="109337b7caed3fdf82b3251c35ea3329">
              <SHORT-NAME>IBS_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16ef0ad87bb336f5b213ce1dc1919787">
              <SHORT-NAME>IBS_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d1ecedc9ab87374b9f44621ab83f6b50">
              <SHORT-NAME>IBS_NM_RMSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f7697ca271193b0596a0c87f09b048cd">
              <SHORT-NAME>IBS_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="14d2d5c7cf7d32cc8fde6c041595dd01">
              <SHORT-NAME>IBS_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bd9379194c283eb28c5c0461a7a0d428">
              <SHORT-NAME>IBS_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5cafe1fa0f5a348b9de666e743e91246">
              <SHORT-NAME>IBS_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65d1343ee94432108b3cb7fdf6f862d8">
              <SHORT-NAME>IBS_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f8610f8b63b3dc4a297bc5c05802b8c">
              <SHORT-NAME>IBS_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c22fca2f5ae31b68235d00dead0f96c">
              <SHORT-NAME>IBS_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed7a8f2459d53b1db22e69705d944aee">
              <SHORT-NAME>IBS_NOI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="408317d8689c3b8b8aad3a3aed9af73e">
              <SHORT-NAME>IBS_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="73d86b5bcbd037be957462b0db4df2c3">
              <SHORT-NAME>IBS_NWI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2bdc1e0d867e3b7f8d69a52e200620f0">
              <SHORT-NAME>IBS_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cc8e617477773f36a7798dd1d90d3703">
              <SHORT-NAME>IBS_SFAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_SFAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="870d857ca35d380982fab971ebf57052">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ada545e84db43dada797b7829a99d5b2">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db72ba8021543c3fbe2ca86ba63ed627">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33ee83c3f44e3e49bd4120f330096842">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc3e443b75a330fab2e772e2d6b97f0e">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d10257347c2c3d629b18ff94d4806f74">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b497a4dbc5c38bf948e414ae1297e86">
              <SHORT-NAME>IBS_ZONE_20ms_Group08_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IBS_ZONE_20ms_Group08_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a4ad3811830f35c5a8d0cd09e485cedd">
              <SHORT-NAME>ICBAD_100ms_Group25_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7193071c22d431a4bf3badd596eb0a72">
              <SHORT-NAME>ICBAD_100ms_Group25_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="776d09997f563ac381055eb5826ddff9">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf2db8d4f85c310abed1e680c13337f1">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72125930ab2734b9b96fd38484d1baac">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="87ae3b220c1233669647fb856809f04f">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="742c27de309b36b0b87b8c32468380a7">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved135</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved135</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9906076138df3dc0a4e28564909e433c">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved143</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved143</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6256db52ba863dcdb31bd6ea0c3c770a">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1665051971c730b4a4d26d80ad667d59">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved151</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved151</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7cf45d48de20341bb2d19fbdee5e86e4">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved159</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved159</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9fb5af224f5d39d09467d67e007c2223">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved167</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved167</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a63ff808b843e24af7ea851ec8c1785">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved175</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved175</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21f1dd2cf87338b3986a635f9dfbad98">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved183</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved183</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5f68e5203f9300ab572c0b72d2fa567">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved191</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved191</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2b154416328838fdadebca0de3f49503">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="19708ad876c43a42b72eacad29993ec7">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="383c6159d2de3bb3aff8d05c30cf3fc9">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08a6b81d171c304dabe45c685101ae38">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3fb6e273410c344e89c5bf85d1f5f196">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96bf7d8a16f53060a8e68b1e66ea98e4">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5f7a7eeea8a73498bd2d5535bb3fefd8">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="54dec3a6542d39d5835c2a265bd9895e">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8de76e1a73a7362281e0426f188aee3e">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved87</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6392462d74b3ef7be279f5ab7d95668">
              <SHORT-NAME>ICBAD_100ms_Group25_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group25_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbe1690f52a438fbbd9afc672176a4a0">
              <SHORT-NAME>ICBAD_100ms_Group37_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b94a969ee1203569ac59799627b4d965">
              <SHORT-NAME>ICBAD_100ms_Group37_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b817eedb6e23a82839e1c4badba0569">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b19f6673101339d9522c5ae4e5642e2">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e28462ceaea432b59c2ff17aa78fc552">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58d016c8c5dc3ca784b801feaa911630">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="60e5f7b1d7863ead81dc4f47c9a58c02">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="336c851b974d38db9fec4893fccf9321">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c1d7e4de481c3de290617aed3bf9a212">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="54feca71534a32d5ab90d3612d6d74e5">
              <SHORT-NAME>ICBAD_100ms_Group37_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_100ms_Group37_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2edf3348386a33aab4515608277a428f">
              <SHORT-NAME>ICBAD_10ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0323a81aa32c3ce6ad82078fbd26ba5e">
              <SHORT-NAME>ICBAD_10ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d734a0acc1353d46afb9b3339e6f3aac">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4df3f811d7d034beae9b666153cba326">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0ea319ab2dd73999ab7b30fb78962745">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1999673315603483a4a208f85daadeea">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="049a36202cde3035ac8145b5b28236c4">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1dcd47a1e2793233b9dd8698c0269cf0">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e655f6dacea367b9be670fa40ea0469">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8ba8f6427db03272b90b076928fbca8a">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c453314bbea3d9aa7d882384eaa5caf">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f094e66edc53aaf9a1fa8e047b00bd3">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved18</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="268ab5d82c743a04a822bdcf61f94e54">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved19</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2d7a18196d2a3d74b03fb164f8742e62">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7814185e2d8309f82a8ea62c597f403">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved20</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3e80db30dffc3841919d992ef3b7c5d1">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved21</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved21</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ef1cd79866e834e3819ca4adba46ca40">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved22</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved22</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3749ffa0a4fe3da495f79cc8ba11b47f">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="44839e33e32e33d1bce85f3550221cd8">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31e2ca4dd2733f29b8bcbb5155582538">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a9b10fe20bf831e5a25c3603bee212ed">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e539915f2a933349bfb845d03954fb6">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c95d2b0108e932c6b970e7b7043e5ee7">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b741ff7a1ef2361394a219ec1af05d72">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="74d95d57b9eb38b2bb35d8b43551f181">
              <SHORT-NAME>ICBAD_10ms_Group01_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_10ms_Group01_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb17661218e53d21977e244dc8a22e23">
              <SHORT-NAME>ICBAD_20ms_Group05_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f53fed9550c3b2bbb8e8efb11649116">
              <SHORT-NAME>ICBAD_20ms_Group05_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="42794bf2dbce35f7b61a349f824d8f9d">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a04544f58ac3c40a9b2cc9f23f351c2">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d1b8eccc382a3abe868186065b90c20a">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4368fff7dc7335aab0831c2f3c8bc304">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1b5fbcf36a283a00b1ba8fe70e1e07d1">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3760f3f7a0833fb0ab6245021296900d">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39ff851a9ae4367fbab712e83504ca4e">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="466138cb40483c16992c84f5ae300eaa">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c3442c03e140337f9ff64ec45c540c72">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1725ff1919aa384a98d65d2a661ec687">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8683dd37bac43a4bbe0ee2096db7a2e0">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0acbbc2a19b13c0dbd876361820e2656">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cf07f05bc1983925a97d2c4345264c82">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dbce5f90d9c231a0bed58a128f3798cf">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57a758b8ff943a5cb627039bd2c077d4">
              <SHORT-NAME>ICBAD_20ms_Group05_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group05_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8f61df2500963deeb4dbc38fceb36c92">
              <SHORT-NAME>ICBAD_20ms_Group07_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group07_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47dde042d92f391da74c39eb21212462">
              <SHORT-NAME>ICBAD_20ms_Group07_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group07_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e411a24e80873f06b22d308afd8a3c59">
              <SHORT-NAME>ICBAD_20ms_Group07_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group07_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0717ad4b802433d7bb3ee6b500f0de3b">
              <SHORT-NAME>ICBAD_20ms_Group09_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e2066f9ab9033d480ce3dff889dee97">
              <SHORT-NAME>ICBAD_20ms_Group09_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ed9f0a8fb3bf38a5801c15819a2d12f9">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="68a1bafa0a8331de87c5b7afedc157dc">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c44eb75056c3159833da0fdbf6468d2">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2d2c01f3712c30edbee2997d50fc256a">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ad46019099f838bda10a45d1a64dad10">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd6fdc4ac6563a85a7fe3b3f665bff48">
              <SHORT-NAME>ICBAD_20ms_Group09_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group09_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b31a65bd18893872ad0be9eca4fbe193">
              <SHORT-NAME>ICBAD_20ms_Group12_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1e2de3b3c9c7350cae13b91b67ed3062">
              <SHORT-NAME>ICBAD_20ms_Group12_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ef327fd2b913314a699e787242e5cbf">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b22401407cdd30de9caa5218dd1f3f6e">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f9f608dde02d3507be2892a815d24f43">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e6ecaac1616535af99510a4d63514d2e">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d4fa976a099e3215b524d4489f6f3335">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="886c10bb68523df0b2bec07a17fd7a38">
              <SHORT-NAME>ICBAD_20ms_Group12_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group12_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fcbe9c7b16a43f03924c32e19e8219c4">
              <SHORT-NAME>ICBAD_20ms_Group13_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9a32a786412314fafc9eb3a42774c2d">
              <SHORT-NAME>ICBAD_20ms_Group13_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dccf2798c3d93500ae2ca451deedf1a6">
              <SHORT-NAME>ICBAD_20ms_Group13_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="818a7c1b6b13322c8c7fc17270f18c54">
              <SHORT-NAME>ICBAD_20ms_Group13_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="973e69935b56351eb9422cfd1eaf9aae">
              <SHORT-NAME>ICBAD_20ms_Group13_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6bd72d26d332376f8fbc3ee956734978">
              <SHORT-NAME>ICBAD_20ms_Group13_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e68b92a88ff135cf947beaf0826792e8">
              <SHORT-NAME>ICBAD_20ms_Group13_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group13_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c5c2fdfc13c430f0880d789657a90dff">
              <SHORT-NAME>ICBAD_20ms_Group15_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f5bfcc50b21336049e4d371dd0779e6a">
              <SHORT-NAME>ICBAD_20ms_Group15_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82d4663d9f2431a38a58a4f6df6ead4a">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8762d59b22aa3343a813221e16c51f3e">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ddaaa403aa7e3394a1f20e0745a3519f">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f5fcb570af534a382300a1500307f7d">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f7551a5600d34888423638b7ea34392">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcd3f495426d36139e7dd3c4ed5a2f67">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="69d1772530f53c6ebf47c5c36a9a7337">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c4dbbe1a9ab33d52a01b43199412dabe">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c0246cca718357ca767437a6eb4ab4e">
              <SHORT-NAME>ICBAD_20ms_Group15_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group15_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ffd243a4a2b832fba81009caf296453d">
              <SHORT-NAME>ICBAD_20ms_Group46_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group46_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b49f5b728cc361980156664722c13c4">
              <SHORT-NAME>ICBAD_20ms_Group46_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group46_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2cff06e2b9313515a9561aacd07b4b8c">
              <SHORT-NAME>ICBAD_20ms_Group46_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group46_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88232550f3b63672944e798ef7c6c9e8">
              <SHORT-NAME>ICBAD_20ms_Group46_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group46_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="127b7f889c5c376e854219041e6c9469">
              <SHORT-NAME>ICBAD_20ms_Group48_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c0aa431397a3cf6924c94a633c97cdc">
              <SHORT-NAME>ICBAD_20ms_Group48_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="16ffc8dc1fb73e15832cd151b34ff6c1">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d552c971a202352dbc608c6fa25b4056">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2135f236572f367e911de8c958fc34e6">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2925ecec11d93ce6b0e623cdb6a9b047">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="44d8474933d0338eb1d131e46a7b703e">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4eeaf52a316f3cd5a0b9b751d02be0ee">
              <SHORT-NAME>ICBAD_20ms_Group48_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_20ms_Group48_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="338e2e8f976935b3aca9fff83531627a">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e96380889c9d30bc808661bf0ab59050">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57f8f02689153da7ac7e439cb413bcbb">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2e24885af363713b9fc18a9ebe424d7">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d277325f582a34eaa823a88111e3088d">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a7934f2b9fd23958ac6ce5365df93a10">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e77f9ff5571f3b55aeccd1f6ddf84ff2">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce776c6f2c3c33a898ca33ef163fa07d">
              <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_10ms_Group20_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3dc86202993e323fb2d88a1ac68cf7f3">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="25d6c6bb148832df8620540fd016150b">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3e1e0a2926ef35d18cedbec0f91dcc35">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7cabea8a1ad43309bc330af87a3f630f">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d8fd0b15f6a31cf8303bc93d86866fb">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f051b3fb5f2c3ab683b6e4dc912a0b60">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="83c88787df683c38b23ec6b132a4f6d9">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48d78e57dbd23a7cb51d6f456f3bd5f2">
              <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBAD_ZONE_20ms_Group13_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1556464803b7303c85b946e7ebff0137">
              <SHORT-NAME>ICBVC_100ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3f567fb7d5da375c90ccccb4a367d5bb">
              <SHORT-NAME>ICBVC_100ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ada94c58a99d341591178dd29dd2c43e">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="91648a10354431079983d9ad601ebf74">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a7d02d65c66c3259a1939a4fb1315fe2">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="80e7817557ca3f6e90e3c93c8c03cdc6">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59da12444d5337569cf75d144c2a2462">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ca240065e52322d8b959a82745edb37">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved21</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved21</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6733095d2db3d4a9d32b8887d38d88a">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dcbc61aa662a34b7ac6a40ee8b68cbbe">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="985f43c4aa4a30d0827e04003b2eabe4">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1b2a8a5363043a6197364dd391223b91">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b9601754c1b630bd95c4fa7d198b6252">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b995ced3e9d23d6b93ea4a30764bbc70">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved72</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved72</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b9979026f99308185f4dc851f409dbe">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="08d4d816225c39be90c1f3baf5202bc1">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved80</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved80</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="70bcb3b73d0b3b17a794c89c44d6f115">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved84</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved84</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="af17e29a6a743c758fa0c8f0dbbb2f06">
              <SHORT-NAME>ICBVC_100ms_Group01_Reserved92</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group01_Reserved92</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="88bbac680f87313c944aed5ffae4dff0">
              <SHORT-NAME>ICBVC_100ms_Group19_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group19_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6c8f55db11d13fe48700d29fd060824c">
              <SHORT-NAME>ICBVC_100ms_Group19_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group19_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eaf8c02b3f663bd0b3dfaa782c9e2981">
              <SHORT-NAME>ICBVC_100ms_Group19_Reserved21</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group19_Reserved21</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f9a4080d4ef837268ec1241fbc2b2aed">
              <SHORT-NAME>ICBVC_100ms_Group19_Reserved35</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group19_Reserved35</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9fdcef5299a135d7b4a520e7dd95fdf9">
              <SHORT-NAME>ICBVC_100ms_Group19_Reserved58</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group19_Reserved58</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2212121ceeb83edea3f204fa26a9372c">
              <SHORT-NAME>ICBVC_100ms_Group80_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group80_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c908d199a8e3ce18178941a58d4eaf0">
              <SHORT-NAME>ICBVC_100ms_Group80_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group80_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f12652e4fd583e8e8f1fe486f6a268b4">
              <SHORT-NAME>ICBVC_100ms_Group80_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group80_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f64ee7fa48e73471aec16746ac1fc42e">
              <SHORT-NAME>ICBVC_100ms_Group80_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group80_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="768d4b94c0bb379098732d65af40d00e">
              <SHORT-NAME>ICBVC_100ms_Group80_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_100ms_Group80_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48d92b6ae85a371ab9a6287833a70d21">
              <SHORT-NAME>ICBVC_200ms_Group79_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_200ms_Group79_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b3e4565396434dcb95690c9f1737d05">
              <SHORT-NAME>ICBVC_200ms_Group79_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_200ms_Group79_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81505f385af331c1a00714d0aabc1881">
              <SHORT-NAME>ICBVC_200ms_Group79_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_200ms_Group79_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0528f26a7b493af3a7d4f1c7681900aa">
              <SHORT-NAME>ICBVC_200ms_Group79_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_200ms_Group79_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="34ee9baf5cf434088aafbcadf77ff855">
              <SHORT-NAME>ICBVC_20ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="917360dbd6b13a64a0c3b0a2983d58c2">
              <SHORT-NAME>ICBVC_20ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d424bbc94aab3824b4d9c9440a35334c">
              <SHORT-NAME>ICBVC_20ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7cbe00ea81b3957995af0cc1fde3a2e">
              <SHORT-NAME>ICBVC_20ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05e11309b74330e0a5a4ec8c0061d3c2">
              <SHORT-NAME>ICBVC_20ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="63826378374039498dafd36dc2be2950">
              <SHORT-NAME>ICBVC_20ms_Group03_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_20ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e66adf94d4e38c9b39ba2c6072d019f">
              <SHORT-NAME>ICBVC_50ms_Group11_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb79ed1f1b8a3c479c34d7370dc5b2fe">
              <SHORT-NAME>ICBVC_50ms_Group11_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="35838553baa933e580a1139414e199ca">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="67f14148af1d38a7961db46eb8be7852">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="64be5884fdab39c685b9604ca0ea070d">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="390b6d7c901b3cca9035c3e3af96a39a">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9902e4253363030b318dbfe9ba0d7fc">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="11f17386f5463945bd40595e11989f4c">
              <SHORT-NAME>ICBVC_50ms_Group11_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group11_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d685097e25535eaad78f3b1e2c2f110">
              <SHORT-NAME>ICBVC_50ms_Group13_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5325a9466d34331295aece1a7b60da3a">
              <SHORT-NAME>ICBVC_50ms_Group13_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eca92291401439f285022701841ec59a">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="94b33e7564593a9ca3a915c20d9c1100">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="83c55c031fb93a9e946dc86307b7530d">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e1fa93c176739feba44bdfa54e7550f">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f80c5f9fe7bb397ca782b1eb7cad4217">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6be54f2df832325cb20e151b597991d3">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved14</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="92579a4d9ac034c3b0bdcd76162aa5a9">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5fdadc96fa2e33a7aae641d80e9f719a">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f44cb66101483ea0a96ff8642c994779">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6fe04fb7efc13fa38ce8b02a845d312a">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce09b1a0fd22335f86bbe6ef273f59bd">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48fbdc5dd9793d4ba32f9f2dcd77cf4f">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f94b50408b8732d6a2d2efb6ab786eca">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="39dce9c7a4663b9f904a93822668c908">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d274950dcb4533a38296faac8444aaf1">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52414170a2103093b5dae15d32f331b1">
              <SHORT-NAME>ICBVC_50ms_Group13_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group13_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8c167b717dcf302f93724dea584b4316">
              <SHORT-NAME>ICBVC_50ms_Group158_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f35cedf9c073ba8b870f1201b60b773">
              <SHORT-NAME>ICBVC_50ms_Group158_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bbfed698de66360a98e57a2296e5d02a">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ac888cb1c7c30fcbb0cb77d831c2e43">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6cc047e666033fb7b56a26d41c3fc382">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d415db313cd2310f8fc85027a3f5942d">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="81702c4ae3dc3b6ca37bbfd9952510de">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved13</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d55d667a2e1308786131da6132b469f">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="108358800a883f88937abb10fd409d50">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4378cd81388338bb1ae19272258d98d">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="589aefdafcb332f9bc32e7bed93ee536">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="995a6e6eeedd345391253cfb44b23896">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="74657df802783fadb827084b854e6d78">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4f28f96e52b735febcb9afb32da48da8">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8761745081a037c7a4c265ee6c79de45">
              <SHORT-NAME>ICBVC_50ms_Group158_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group158_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c7f3706c7172312282ba7cf1022c66e8">
              <SHORT-NAME>ICBVC_50ms_Group256_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="df5331d585633b6ba87f2fa4239fd953">
              <SHORT-NAME>ICBVC_50ms_Group256_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e98c1068e2fd3cebbf85eb804e716c13">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved100</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved100</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4afc43fb35493e6193baf0594874d659">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f41a77a231f83844880e4e275faee3c7">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2f576800688534699ab9fe68632fa535">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7b2dd7ef5ef30a1ab19535084594f97">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2e17fdb9dfa839e5b5d37c3523cef4cf">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved85</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved85</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6f806c4aa43230c7a6c9c3a66c09cefd">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="56ab17d887313ebea60e74489f61a733">
              <SHORT-NAME>ICBVC_50ms_Group256_Reserved96</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICBVC_50ms_Group256_Reserved96</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="22ece2f549903a1bb78c138081e3908c">
              <SHORT-NAME>ICCPCBTemp1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCPCBTemp1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="756e905885023bb68a47ec52e7b86fd1">
              <SHORT-NAME>ICCPCBTemp2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCPCBTemp2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b51e3df55f13eb3969f3e0372112070">
              <SHORT-NAME>ICCPCBTemp3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCPCBTemp3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fdef31290edc35269a4bca183b3e20a6">
              <SHORT-NAME>ICCPCBTemp4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCPCBTemp4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="adabb17b6674373fbf32ad52c6248418">
              <SHORT-NAME>ICCPCBTemp5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCPCBTemp5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e831e7ec25443bbc9727bc1be6d0ead3">
              <SHORT-NAME>ICCThermalCoolingLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICCThermalCoolingLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f221f3bef1b535039f4b83a898915956">
              <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMDrvrDstcnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="354d7e69cef53aee87da3d134a74f779">
              <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMDrvrFtgLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2de56894fa8630369b536347ceb4b030">
              <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMDrvrPrst</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8bbcdd78032433bcbf8472cba959c92b">
              <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMEyeOnRoad</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cb92bb782614374f99c45c97662d26ce">
              <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMSwReq_Reserve16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="33e215bdda633a31ad677f8f684f2643">
              <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ICMSwReq_Reserve17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3436e2dc9cce3940b2af9d7feb86db54">
              <SHORT-NAME>ILBRReq_IMM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILBRReq_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6241b212de6c3ee381c5b3f2ee2d1422">
              <SHORT-NAME>ILCActvnDircnDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILCActvnDircnDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="529b16a3062e3162b6a69b0547bf0ce8">
              <SHORT-NAME>ILCActvnVelDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILCActvnVelDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9db8600ab02635f38a0e5e1d4961a06d">
              <SHORT-NAME>ILCSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILCSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb3b3c86371a3d3fa608bd877d88fe47">
              <SHORT-NAME>ILCSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILCSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d3cdf4778bc437b891d22089a25dd9c8">
              <SHORT-NAME>ILCSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ILCSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="00349f36e43138eda2892a2c1ecdc39d">
              <SHORT-NAME>IMATESysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMATESysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="176061d041103fafb2831eab3420b232">
              <SHORT-NAME>IMMPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3141249dd07e3c5387440ceb8ad3852d">
              <SHORT-NAME>IMM_50ms_Group02_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e61e2149aaf939738e33285ae1d477c0">
              <SHORT-NAME>IMM_50ms_Group02_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8fd128ffcb9e3d46a8b4b1202b4641d9">
              <SHORT-NAME>IMM_50ms_Group02_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f84420e8daa838afb7e234294c303de8">
              <SHORT-NAME>IMM_50ms_Group02_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4600f351ac1b318898add8e120c740d6">
              <SHORT-NAME>IMM_50ms_Group02_Reserved143</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved143</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f40f6729bedd3edc8b9f2104b8687ae1">
              <SHORT-NAME>IMM_50ms_Group02_Reserved151</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved151</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e3782a9c61d37deb84364ad2d83b966">
              <SHORT-NAME>IMM_50ms_Group02_Reserved159</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved159</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a416c1a573f73f05869ed8b669859eec">
              <SHORT-NAME>IMM_50ms_Group02_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7de4d89e247e318da8e6a95cbb5bc434">
              <SHORT-NAME>IMM_50ms_Group02_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a5776fdfd6283409a37fcdab3a29799b">
              <SHORT-NAME>IMM_50ms_Group02_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ba97b9afba8435a6b00d534403bfd511">
              <SHORT-NAME>IMM_50ms_Group02_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cd923b37fab937c7b04763fbf2ade06b">
              <SHORT-NAME>IMM_50ms_Group02_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="59b653f179c334cf808d8b2c8e3a2ee6">
              <SHORT-NAME>IMM_50ms_Group02_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cbdd936289bf3fcc8ade6467bf928ef4">
              <SHORT-NAME>IMM_50ms_Group02_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c51b2176e8b322d968507ab3f0946d6">
              <SHORT-NAME>IMM_50ms_Group02_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_50ms_Group02_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="de67f4dda59a3baa8058632d7886b3e1">
              <SHORT-NAME>IMM_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="538e6a836771320f8ea901d6025e6c37">
              <SHORT-NAME>IMM_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="97ab9c7b0a48372bb44969f6e0f69db6">
              <SHORT-NAME>IMM_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1b3573ee0e1733bea8c6d92428da53a7">
              <SHORT-NAME>IMM_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3bbd5affd73d3a08ba3d24d34598ca94">
              <SHORT-NAME>IMM_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec32c8a28b27399d95c008e1b06e4e50">
              <SHORT-NAME>IMM_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d852970730f935918cf2711b373fac11">
              <SHORT-NAME>IMM_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="44b38c6df9dc3c1a9a5397502a3d1476">
              <SHORT-NAME>IMM_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1ee916e0a77535a2b5f02acba08cc5b2">
              <SHORT-NAME>IMM_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7bddf56c81e336538c119f2208579723">
              <SHORT-NAME>IMM_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5b2d5c44b5983d36ad8dd37f525e15aa">
              <SHORT-NAME>IMM_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMM_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72775402bbd5319b9817630c70b170d4">
              <SHORT-NAME>IMSPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b336be6a88bc39ac9a3725d9a9ea686c">
              <SHORT-NAME>IMUTmp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMUTmp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da3b24335de53a28bda1b49889c898b0">
              <SHORT-NAME>IMU_SN</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMU_SN</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="025326f9fc683ec8a8c78ee99c532f08">
              <SHORT-NAME>IMU_Signal_status</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMU_Signal_status</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b0e1af6f95a306ea529e7c62020d8b8">
              <SHORT-NAME>IMUseq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IMUseq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9113087b49073d7a9802e60cf1d65b08">
              <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDAVCamrHeatReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="65f2c2520f5f37e4bea9738fbe14bffc">
              <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDAlgFlag</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d4500e855f783512a506a4465ab75163">
              <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDAurixTemp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fcfcc7032d573af2ad96e0e395c08ebe">
              <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDComKeyEnbResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="710e641ce9293b4da0265137c99456ae">
              <SHORT-NAME>IPDDataId</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDDataId</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58f46fd1958b3f98a14e338d1567e8ee">
              <SHORT-NAME>IPDErrorCount</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDErrorCount</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5c4900d2757235dcba421493bf0868fc">
              <SHORT-NAME>IPDFailedReason</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDFailedReason</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8b49615f74793c3bad56f878f37d4934">
              <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDIdentityResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5fdfb3c8d1c73505967534451e53124e">
              <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDKeyStatus</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e60f1f392033c5daa202e2ae3b5c296">
              <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDMCUTemp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f50ddb571dba3a61be07ae852c5523b2">
              <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDPCBTemp1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7538210dca2631c5a5d9bc2a606e7816">
              <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDPCBTemp2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bfb88df357f3389e9dd8121f4dfc7d53">
              <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDPMICTemp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="96f51edf6d19351ea00593ce052b1f2c">
              <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDPowerFailSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="873a4d3034b43fc39eab46825a00a9bd">
              <SHORT-NAME>IPDResetCnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDResetCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="29b28c7924ac3773befa8ce9f10cad51">
              <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDSOCTemp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eea4cfc9e9d43f249e9365948065aca3">
              <SHORT-NAME>IPDStsResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDStsResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5991023cdba93f59a5d569e6e350c669">
              <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDThermalWrnngLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3a48a660e157373ebcd076cd79b86a3e">
              <SHORT-NAME>IPDTripCnt</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDTripCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="908b73200d143175a1d9f711fcdb808a">
              <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDTripCntResetResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9bf39e4e5725391488533a9984a2f7de">
              <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDTripNvmTag</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="723186026ec23e14988b62a97ec0a261">
              <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDWtrClntInltFlwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f112eae9ae6e3fd5962add26484574c6">
              <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDWtrClntInltReqFlg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc420f64174437f9956dc93483bc11e8">
              <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPDWtrClntInltTimeReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5dbec5351d823ae9a8b4f8e80b0fa4a3">
              <SHORT-NAME>IPD_20ms_Group43_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f39d9680b11329ebffe6c2b4e6a104d">
              <SHORT-NAME>IPD_20ms_Group43_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cab7b8babd5f32b58999258b1882c278">
              <SHORT-NAME>IPD_20ms_Group43_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="935a1a07107d3a6fb903d4bcab363f75">
              <SHORT-NAME>IPD_20ms_Group43_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="db551a1207293f44ac6cd6bc771bf9b9">
              <SHORT-NAME>IPD_20ms_Group43_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c77e57a30a623253877475519360c560">
              <SHORT-NAME>IPD_20ms_Group43_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea2cf9be4cb33bf5891c3b129c892ea3">
              <SHORT-NAME>IPD_20ms_Group43_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group43_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab00d6c97bc5349aa06addb151356821">
              <SHORT-NAME>IPD_20ms_Group60_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f8acd24f14673d7e8654e8108638f148">
              <SHORT-NAME>IPD_20ms_Group60_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dd2c9b3e1efc34e98a4ad81b5a1c9129">
              <SHORT-NAME>IPD_20ms_Group60_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="038b36e5dc4233269eb03f664cadb096">
              <SHORT-NAME>IPD_20ms_Group60_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9b82b70c60ef3163a8be0f423ca85c44">
              <SHORT-NAME>IPD_20ms_Group60_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a34ec872bdf53d40a1ca8db9dd0b2094">
              <SHORT-NAME>IPD_20ms_Group60_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d80c54767b753d279ca87d1433519ac6">
              <SHORT-NAME>IPD_20ms_Group60_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b033af2eb869306e883d525dfa99b62e">
              <SHORT-NAME>IPD_20ms_Group60_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="026d01e89d753073a9a815d693cc647b">
              <SHORT-NAME>IPD_20ms_Group60_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec213b008e9037a09a65395251fe0301">
              <SHORT-NAME>IPD_20ms_Group60_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="78304f527cdf39778cc67dc419d56499">
              <SHORT-NAME>IPD_20ms_Group60_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="faafaca52e303d4787cec199351b5838">
              <SHORT-NAME>IPD_20ms_Group60_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group60_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ea75c58b27ba39ac9a242e8dcf0b34cb">
              <SHORT-NAME>IPD_20ms_Group64_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8608bc030aaa3e3c9f8b69eb14f08f38">
              <SHORT-NAME>IPD_20ms_Group64_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="706fb5203c55362b9861dc77391dda22">
              <SHORT-NAME>IPD_20ms_Group64_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ba85236d06e3b17a5955755464f14ef">
              <SHORT-NAME>IPD_20ms_Group64_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8ebaf63b39873749a7bd3fa56e6e1cdc">
              <SHORT-NAME>IPD_20ms_Group64_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="574c47a14f0d3dceab5e5d5545b0ffcf">
              <SHORT-NAME>IPD_20ms_Group64_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5789f9a9b0d63dbe98ec94fa779aef08">
              <SHORT-NAME>IPD_20ms_Group64_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0b85457b94f1339f9c77e56b0fa9bb3d">
              <SHORT-NAME>IPD_20ms_Group64_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc78a3e9429333279814d2fa27b3fff5">
              <SHORT-NAME>IPD_20ms_Group64_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9f44fa105fe23180a16f304dc019aa79">
              <SHORT-NAME>IPD_20ms_Group64_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="591875d2df8a36c6a8ae7a8f0acb538d">
              <SHORT-NAME>IPD_20ms_Group64_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="83bcd67a9f053e6d88f41409b71373de">
              <SHORT-NAME>IPD_20ms_Group64_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group64_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="019a88a2129f3973a0fe1aba1c3f5c34">
              <SHORT-NAME>IPD_20ms_Group67_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f9b3b134938f3f4596cc7909ec37e587">
              <SHORT-NAME>IPD_20ms_Group67_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e76671cd5ab139c88793fd0971fdfaf6">
              <SHORT-NAME>IPD_20ms_Group67_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="76d62324c31b33949567cb221519d226">
              <SHORT-NAME>IPD_20ms_Group67_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="358506c1d1873f4793236d281d3aaf08">
              <SHORT-NAME>IPD_20ms_Group67_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a88c5a6dcc6f37a0819ab75a41921556">
              <SHORT-NAME>IPD_20ms_Group67_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9beedb5996f935ae9731655b2931a8d3">
              <SHORT-NAME>IPD_20ms_Group67_Reserved15</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b5cdad3148213ae48a6412fe3e6c4a9f">
              <SHORT-NAME>IPD_20ms_Group67_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="12013b119322329c9ec18f21d927ac94">
              <SHORT-NAME>IPD_20ms_Group67_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="697c34d45da239d1bdafbf48b141600a">
              <SHORT-NAME>IPD_20ms_Group67_Reserved39</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved39</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4b1f3cc0d16d34ac95fb984c5d41a347">
              <SHORT-NAME>IPD_20ms_Group67_Reserved47</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="17043638daca32aba1baef86cd36c3f9">
              <SHORT-NAME>IPD_20ms_Group67_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="84047d3148783a78a78d6c7656ae2d0f">
              <SHORT-NAME>IPD_20ms_Group67_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93ee87b548cb382ba8d6b9e2fd2e8930">
              <SHORT-NAME>IPD_20ms_Group67_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="42698ee589e937288e76a7d1839289bd">
              <SHORT-NAME>IPD_20ms_Group67_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_20ms_Group67_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e86fbfbc59f315eb1a3ae7d4d98d603">
              <SHORT-NAME>IPD_50ms_Group14_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf24d6c07d763dd2afbf15cc0bec9a37">
              <SHORT-NAME>IPD_50ms_Group14_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1aec9aafc1b33013b098649ef6845156">
              <SHORT-NAME>IPD_50ms_Group14_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52c14c19cbcc312e948072e4737878e0">
              <SHORT-NAME>IPD_50ms_Group14_Reserved10</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7e80c42123993419abb0c51ae3e3aef6">
              <SHORT-NAME>IPD_50ms_Group14_Reserved11</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a3baebf889731f3ac455e35f81a923b">
              <SHORT-NAME>IPD_50ms_Group14_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="77c21edc9f1a324da139caacff01700c">
              <SHORT-NAME>IPD_50ms_Group14_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05313637424239ca92a7d84d1c27b341">
              <SHORT-NAME>IPD_50ms_Group14_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dfbf226656ca331e883cef24cf8807ae">
              <SHORT-NAME>IPD_50ms_Group14_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9ed34083ab83045b8afc1419060bd56">
              <SHORT-NAME>IPD_50ms_Group14_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82ab084620c53387a94c31813d5ab4ef">
              <SHORT-NAME>IPD_50ms_Group14_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32533ebc5bd1355eb483e90cb1a0ef14">
              <SHORT-NAME>IPD_50ms_Group14_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4ac5debbbf9b38549f5891479645691a">
              <SHORT-NAME>IPD_50ms_Group14_Reserved9</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group14_Reserved9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6ddfd3bf7ae43a54baf52c3920d661f9">
              <SHORT-NAME>IPD_50ms_Group49_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75613526ebb930d1a6c8662435b3aec6">
              <SHORT-NAME>IPD_50ms_Group49_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eee3ef02e9543c86acaa423630be98b4">
              <SHORT-NAME>IPD_50ms_Group49_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="49ca1d0b3b57385f8fe9298bda84c7c5">
              <SHORT-NAME>IPD_50ms_Group49_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7ca5856835173cee930a316a0ec3a519">
              <SHORT-NAME>IPD_50ms_Group49_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c3ac65f24173c6abf3f0dba8826ccce">
              <SHORT-NAME>IPD_50ms_Group49_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="51943362c1ad367a944a440390f1c880">
              <SHORT-NAME>IPD_50ms_Group49_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61cccb1ed06736d6b0302c039887aacf">
              <SHORT-NAME>IPD_50ms_Group49_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_50ms_Group49_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1c0e42b5e16d357db321837da43873c5">
              <SHORT-NAME>IPD_BKPCANFDAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_BKPCANFDAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e6bda68dab2132d3a500ca1661ecb295">
              <SHORT-NAME>IPD_CHCANFDAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_CHCANFDAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2636d47442fc3a36bb1aff04c0a1863c">
              <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fce99c1bb91931f8b294fb22bea29703">
              <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NKI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="72a28c7f3e2136749a9eef424317880b">
              <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="21567f8e3e353045aa731364a00e3aee">
              <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="566f433351d239899f29e7632f6654cd">
              <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a3fe0d5a75cf39efba3acbecfa4f8e84">
              <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_BSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9e714cdec4d2317aa0cbf739d45d06df">
              <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3ddb96f43d9a3fad97fcede2bb700ca8">
              <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f44c701580113eba98ebe5ada5a6755c">
              <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f72cdd9b62b13c84b38daf266d41abbe">
              <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f6516295575c3f4ca27b4bb08db62fe1">
              <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c6c77a60d4523ad0a4bdcff6e695c258">
              <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75a9c9eab932383aad47fe4898b9773a">
              <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e1e6d59f26f33c54bfa7513fc7e184ec">
              <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c77eda07f2ed3a6db94601bd45ddfcc6">
              <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d2c0daf1f9063d9994fb2f261906378b">
              <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3dbe7338963a32edad06445bcd66759f">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a0a368fb246f3598a07ab751172cdd26">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_PBSMtoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c40418954ac932abb434e045fb44bdba">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4275760f48833f9fa35bcf22785fcfc2">
              <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e180f54d9fda3113b2cd416e0606c511">
              <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c8a92e8c00f03b7890beaeb90f91ec96">
              <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMSSta_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d795b9e7c50326386a346c314474125">
              <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="52e267e5236f3b90b0994f18bd8ab2af">
              <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fc9eaf872f1a33e483b365460047237f">
              <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b5f8a4c7e2e3acf9e72ddf775282d09">
              <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0bdabf0d5c1b3b139f8dba85527257df">
              <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="90b7c5c831463ba2b1b42170d3bb82f2">
              <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="577520d70eb437f7b3e7bee7e169b54f">
              <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="56ac1088ba2f3cbbb61f4ad559608883">
              <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoNOS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d6a773666d9031b1ae1a20426dae8ba9">
              <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="44644ab49ac030a8882a10898ba03c91">
              <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0e03b471fa663ae88f784f9841ba2f2b">
              <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a9d7779e6f133483835e742304e1b3fa">
              <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoRMS_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3b93eeda21403d9f88e3c19186af6929">
              <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f0bc2a853593e22aa0143afb3362962">
              <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0de243bd71cf3c4c9bdbe42231307c63">
              <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="412d8218ea643b78b512be0593b044ed">
              <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NOI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ec055bea5ea133caa3a1b88a55ecdc26">
              <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f45c9e07758b3cbaa775d6d605ee5bcf">
              <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bf97ed009b9734fba92951d6f585af7f">
              <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5e193a2a367c3c8da70c05c397f4cece">
              <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NWI_CHCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58186fb873d93046a49a58fd1a37aad6">
              <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1d1feab4d4ef39a29e4f7f61c005b62c">
              <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="75b92e0e045938eea7ff97eedd828db0">
              <SHORT-NAME>IPD_PTAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="142e388ab780322dbe64824835af5b56">
              <SHORT-NAME>IPD_SFAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_SFAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="acf2c9257bf43680ade556c6b53a6e26">
              <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IPD_VehLckCtrlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c3ea4dcb70e8332b8395aa49289ff603">
              <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ISGMaxTqLmt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9261e68c59343d988b9f6edc2fa05151">
              <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ISGMinTqLmt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="555816c15d1338dbb3f0e752d10926fe">
              <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ISGTqTgt_Nm</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="da7f9404f7883e61b378c7b780cdbd28">
              <SHORT-NAME>IUPRDnmtrIncmntd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IUPRDnmtrIncmntd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a138489214fb39e5b6b560aa3cc30ab0">
              <SHORT-NAME>IUPRDnmtrInh</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IUPRDnmtrInh</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fafa348e64b336e5bd2d32a613e38734">
              <SHORT-NAME>IUPREnStFnshd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IUPREnStFnshd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="610dd2e0509c38ee9519a5681edba9e3">
              <SHORT-NAME>IdentityChlg</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IdentityChlg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="824eb673f1ee332cb72e7de40b9ef1a1">
              <SHORT-NAME>IdleBstLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IdleBstLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="82d2bc6b14273a839536f1325a6947df">
              <SHORT-NAME>IgnOffTime</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IgnOffTime</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="85b759cd0b7734f5b0e4c770c7246df3">
              <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IgnOffTimeV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bac1ae46f82338cfbd73c51fa575cb1b">
              <SHORT-NAME>ImmoSubModSACAuthnRunSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ImmoSubModSACAuthnRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d0b0cab2638c3527b6ca91e5af30d0fb">
              <SHORT-NAME>ImmoSubModTCAuthnRunSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ImmoSubModTCAuthnRunSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cba162d25caa3ad1a41769d44ebff43c">
              <SHORT-NAME>InerDschrgTem</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/InerDschrgTem</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7b9b7e5283f53ac5a906ee0b73e1b28d">
              <SHORT-NAME>IntlckRelayAuth</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IntlckRelayAuth</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e7aa412c8955370d9d8a2f0c6ba460ef">
              <SHORT-NAME>IterMirPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/IterMirPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7c5e5515eb9431bfb98a0753109e77fc">
              <SHORT-NAME>JAMsgReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/JAMsgReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9d509536ebf93e538a6c798d51d9acc7">
              <SHORT-NAME>KeepPwrRsnIPD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/KeepPwrRsnIPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c56e12fbdf7c3050a12dd46be242f89e">
              <SHORT-NAME>KeyAuthResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/KeyAuthResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="46436d29524f3064922d0ed438579185">
              <SHORT-NAME>KeyDeleResp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/KeyDeleResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="248af62d69f93186b99d968c37cc8dc2">
              <SHORT-NAME>KickSnsrDetnSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/KickSnsrDetnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="84a9258d6d913b4bacab344287e141af">
              <SHORT-NAME>LADSAFnInd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSAFnInd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d9e6a92bc3663c0cbabffdbd5aec2282">
              <SHORT-NAME>LADSAFnInd_Tester</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSAFnInd_Tester</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="384305f3e1f5388cbf849391a501b6e4">
              <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSCurToEndPntDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eefd17aebca133e9a2c58bd0b17fcd84">
              <SHORT-NAME>LADSInfoDispReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSInfoDispReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9aa6b918f26d3550aa277dbe44b0d892">
              <SHORT-NAME>LADSInfoDispReqToICM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSInfoDispReqToICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48a6c83fbd6837efa798b4596ce886a5">
              <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSInfoDispReqToICM_HPP</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e8337d0c119c33f6807d021f68f64867">
              <SHORT-NAME>LADSProgressBar</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LADSProgressBar</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b898fd7fda3f3ba2b418fc0cad143e5c">
              <SHORT-NAME>LBSDAndLCAWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LBSDAndLCAWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="558be8c3bbc13ce6bcf68ca5cca7da59">
              <SHORT-NAME>LBrkLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LBrkLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9921b94996f33b96a92766bba8d30613">
              <SHORT-NAME>LCASelReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LCASelReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2c5a59bde36f38b084d827011930ba62">
              <SHORT-NAME>LCASelSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LCASelSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="49b36ecf1ee43c2595ca81ef4e6b8ef4">
              <SHORT-NAME>LCRInHMI</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LCRInHMI</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="83ff7e6383e03daba6e520104fa6ab4b">
              <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LCRSwDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7d6af301af783f338d228326b0424974">
              <SHORT-NAME>LCRSwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LCRSwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="561a1f9343343965a0826e2c30398a3c">
              <SHORT-NAME>LDOWWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDOWWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e3aef126fbb4314ca7cf93ce29b0db18">
              <SHORT-NAME>LDWAdoWrnngDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWAdoWrnngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="55c6bff4ab643606a63a18a65dc5ab47">
              <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWAdoWrnngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="dc43de8598573d43bed7b5c18ec16776">
              <SHORT-NAME>LDWLKAAudReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKAAudReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ce49a24401ed3c51a8dad4d2da72bb13">
              <SHORT-NAME>LDWLKADspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKADspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bc94089cdeaa3d26a217d0b2d4cf93d0">
              <SHORT-NAME>LDWLKAHptWrnngDspCmd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKAHptWrnngDspCmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="13e9ca52aaf53e2caf2ac7c3df88bb8f">
              <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKAHptWrnngReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a13b0506aea13035b6bb4f009e980bd9">
              <SHORT-NAME>LDWLKALVsulznReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKALVsulznReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="780421c212a532098a9b822c8e1dc3ce">
              <SHORT-NAME>LDWLKARVsulznReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKARVsulznReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c9ccfa2c99523a92b45f7a10e71186a6">
              <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKASwReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="848f027e20533539a5c5fa4b1edb4a9f">
              <SHORT-NAME>LDWLKAVbnLvlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWLKAVbnLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eff9a718a2d33a638de7fad2919d35dc">
              <SHORT-NAME>LDWSnstvtLvl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWSnstvtLvl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab58579fe1f339cd91cf1ef85e8e6c9c">
              <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWSnstvtLvlReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5ce22437bab336fe93b3c7bceced50e5">
              <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWStsForEdr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5b1ee1d147ac34ce88d76371e0cd5b12">
              <SHORT-NAME>LDWSysFltSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="310933d91ad333609a4498679e3cf999">
              <SHORT-NAME>LDWSysSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDWSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3167db1096643b53a825516163c6d58f">
              <SHORT-NAME>LDayTimeRunningLghtCtrl</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDayTimeRunningLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="57e80066ec0a3b6b9513349d50f265b1">
              <SHORT-NAME>LDipdBeamLghtSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDipdBeamLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5d57ed3f3798388ca2c12fb89abc9440">
              <SHORT-NAME>LDircnIO_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDircnIO_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c02bb53fc993c7092c2450a60b8888c">
              <SHORT-NAME>LDircnIndLghtF_TDM</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDircnIndLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ebb5994d65eb333e953dbeccf442e2a2">
              <SHORT-NAME>LDrvnWhlRotlDircn</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDircn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="23bfc79f413e3ae78e95b24f4ff1f8dd">
              <SHORT-NAME>LDrvnWhlRotlDircnSdslSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDircnSdslSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0605902248943d11a48ee4673c7e41b7">
              <SHORT-NAME>LDrvnWhlRotlDistPlsCtr</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDistPlsCtr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="95689db8735f3797a27246258ffd7993">
              <SHORT-NAME>LDrvnWhlRotlDistTRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDistTRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="31b2d2ec4f6a3083bca6fa38711efe28">
              <SHORT-NAME>LDrvnWhlRotlDistTmsp</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDistTmsp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e240de474a1a3645a3027c368bd01def">
              <SHORT-NAME>LDrvnWhlRotlDistV</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlDistV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a3a5c08c3b0832dba353237ae804bee6">
              <SHORT-NAME>LDrvnWhlRotlRstOcd</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlRstOcd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="8315a53fd46a35b5b4aef79b367941e4">
              <SHORT-NAME>LDrvnWhlRotlSeqNum</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LDrvnWhlRotlSeqNum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7a64fb46ce6637e58c2903ffcb55a81a">
              <SHORT-NAME>LFCTWrnng</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFCTWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c23c29ddf7d73887a7590dad81021f6f">
              <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFCTWrnng_ADAS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0469d6fd0cfb32849864a6061bc4d28c">
              <SHORT-NAME>LFSDA_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="056f092c83fb35b3b0714bcde484f60a">
              <SHORT-NAME>LFSDA_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cbf0280a1a7e3f87a85ab2a48ae13284">
              <SHORT-NAME>LFSDA_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="35ab527d30d13e639f60101063188b6d">
              <SHORT-NAME>LFSDA_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="20ee732e92e23c1793dbe5b2508e605c">
              <SHORT-NAME>LFSDA_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c31e267f1a13063a01a2c86ec4f3ed2">
              <SHORT-NAME>LFSDA_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="904b4cebc36b35218aa82efa37aa6c6b">
              <SHORT-NAME>LFSDA_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9c628f5769703f419047501cd7ba676b">
              <SHORT-NAME>LFSDA_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d79cfef609283b1c8ac988e51bbdbe72">
              <SHORT-NAME>LFSDA_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="22c048381d2631dbbebbad81bfb6714d">
              <SHORT-NAME>LFSDA_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="082bfb87ec223f74afbfd42457c25369">
              <SHORT-NAME>LFSDA_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LFSDA_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="760748d39a9e3b89b9c4dc43fa6970ca">
              <SHORT-NAME>LHAmbtLampPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHAmbtLampPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f74ca813447304a8d69c1a22de78f3d">
              <SHORT-NAME>LHRDAAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDAAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9ebd9545125f3ccdb19028c738941cf5">
              <SHORT-NAME>LHRDA_NKI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NKI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0a6c3c90903c3813bbe35ee9a678bd65">
              <SHORT-NAME>LHRDA_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_BSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e9e18454ac1d3adbbf88c2f77074c88a">
              <SHORT-NAME>LHRDA_NM_NOSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_NOSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e62fa677d3a739a7a557188f7a9160c2">
              <SHORT-NAME>LHRDA_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_NOStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fd5e21e9ea8d3b3f9b6e28c750ee6815">
              <SHORT-NAME>LHRDA_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_PBSMtoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="61930f825acb3e9c92073b320f6321aa">
              <SHORT-NAME>LHRDA_NM_RMSSta_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_RMSSta_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b0e322696cda391eb79838ca7bb5020a">
              <SHORT-NAME>LHRDA_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_RMStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a1a32aeac13c35369c42ebc84c688884">
              <SHORT-NAME>LHRDA_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_RSStoNOS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="32327629f81a34d08428621c94d516fc">
              <SHORT-NAME>LHRDA_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NM_RSStoRMS_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb80732a803c3f3f89dda6ec9957dd2f">
              <SHORT-NAME>LHRDA_NOI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NOI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f044d156b7173e46bee0089e0c0aaa7b">
              <SHORT-NAME>LHRDA_NWI_BKPCANFD</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHRDA_NWI_BKPCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1f284acb40b33e71b58e8db7724dd91c">
              <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHSWPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="fbf1630faf6933e0a81e049b5eaa6f53">
              <SHORT-NAME>LHZCUAddtnInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUAddtnInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e04feeeee953ab8a31db84ad55897c6">
              <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eb373de71c413caebb430e8f1a5a6a8e">
              <SHORT-NAME>LHZCUBkupInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUBkupInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="972396c505ff39b4b2a7b83bf255e483">
              <SHORT-NAME>LHZCUInptVol</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUInptVol</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d2b33e1751c732eab4bc567bf6c15b2a">
              <SHORT-NAME>LHZCUWKSTS</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCUWKSTS</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c90f1c9a8aaf3f9d96ccc29a6b0663cc">
              <SHORT-NAME>LHZCU_100ms_Group30_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="00aef6280b5236218739fef7e908af36">
              <SHORT-NAME>LHZCU_100ms_Group30_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ab849f853b373bedb16c9e33116d9908">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="09f113a52beb33b59caba396edb2e204">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2bed92acc14e37168bc78c308cea7ecd">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved119</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved119</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a230ef931a3835509c7c079c334437ad">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved12</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d2a2b4975b2a3194888c19f2b528912a">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved127</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved127</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e2d925d0f2f031a6b5fb3f1b58e32133">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="93f1d914cefe3fc18a7d25285d1139cc">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="865cf9c238933492b154ed6179619295">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved55</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved55</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f307969166e33ed08a2aaecd9c2da470">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved63</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="49ea233b4a8d3c28925525099372dc80">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved71</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved71</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9fe8a44b5be438aa9ddb8bb17f33a71b">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved79</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved79</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="798dfb92970f354286acadd02a0424e2">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved87</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved87</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c483b30ecd4034f29ab7f98f9c0ac1ef">
              <SHORT-NAME>LHZCU_100ms_Group30_Reserved95</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_100ms_Group30_Reserved95</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3c1ed2def20935e68951e23331a3e862">
              <SHORT-NAME>LHZCU_10ms_Group01_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="cfd4144bdee63ff08fdd8e3c31e0c49b">
              <SHORT-NAME>LHZCU_10ms_Group01_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9feca5aba5ad35c49985e8bef2d06b61">
              <SHORT-NAME>LHZCU_10ms_Group01_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e6f800e342343a9ab03a1e3517d29890">
              <SHORT-NAME>LHZCU_10ms_Group01_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5a638b6832f93b70bf198d8e33f90145">
              <SHORT-NAME>LHZCU_10ms_Group32_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b39511c7b2793e8eb396d06ffcd63517">
              <SHORT-NAME>LHZCU_10ms_Group32_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="1a9e3271261b30c0bb18e410d9951777">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c15a8574ed1332548e9b6e102d851436">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7494953f4d5f3cb7a6506b0c0462abd7">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="968321bd7fa33d2987951a8885a3d148">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2ceca36b414834cea8b65b17e410d40f">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="6a3bc6f8d5723868acc220f0d13159a1">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="41e78ad872b8321ca88fba9418d4d339">
              <SHORT-NAME>LHZCU_10ms_Group32_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_10ms_Group32_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="a8bbce6fe17e346e9b6f6f2673ca27e6">
              <SHORT-NAME>LHZCU_20ms_Group03_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="eaa5df313679374886b06dd53df41ed5">
              <SHORT-NAME>LHZCU_20ms_Group03_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e4ee5b8a46443291920a37669754cd39">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="3e740ce3371935769a4c54a05e65a888">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2fcec5bfbd333b088c675bfab7fa20b0">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="bb6b5c3e7a9f3164bdf8fb96cc95b7a0">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aae27743bc143237b5db880110e6a58d">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b4816f17d3eb3c9d87178c0e17063413">
              <SHORT-NAME>LHZCU_20ms_Group03_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_20ms_Group03_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c3734e4d90430809700d14aa4ea1124">
              <SHORT-NAME>LHZCU_400ms_Group18_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ee2e8623c04e337282b58ab597344e2a">
              <SHORT-NAME>LHZCU_400ms_Group18_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b6d661ddfa3231c09965a9ad07acfde9">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b18c34ad0e1c3a5287d9ae12546fea05">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="7f9aee83e4ed31dfbc811d800548c34c">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="927e55092b253dd38802e76c28101901">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0c4db3060104378f928db49c84da0bf7">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="2947162fabdf3328b86536665f9a5915">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="5252a363a034314ca2bb0989a146fa9c">
              <SHORT-NAME>LHZCU_400ms_Group18_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_400ms_Group18_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="f88124b1a2f6327a8d0cef0f24832d7f">
              <SHORT-NAME>LHZCU_50ms_Group06_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c27954bd9ce73df5a60c3d8d1d502f09">
              <SHORT-NAME>LHZCU_50ms_Group06_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="48e28748896a3da5aaf337050bdf8e0b">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved1</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="122e9cf6be1038298ce22a70878fca8b">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved2</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="4e8895e25fcb367899a175bbcee064aa">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved3</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="05452b69603b325a9b883f96dd551b5b">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved4</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="585fd161602930e1becdc75a84481e0f">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved5</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="e915cd3bb90b359eb97b12d9673e523a">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved6</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="58f96c5ba2b53a8b9308a926cb089b97">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved7</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="04e2e2896a913f328ec25eaaccc964f3">
              <SHORT-NAME>LHZCU_50ms_Group06_Reserved8</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group06_Reserved8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="d4f319d99e4d36cc906c5fe2845a9027">
              <SHORT-NAME>LHZCU_50ms_Group24_CRC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="47b15ead63933394a2cecc697c50d286">
              <SHORT-NAME>LHZCU_50ms_Group24_RC</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="aefe6cf9424b32f29369e7b42bc3b334">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved103</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved103</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="9cf745dbce8c38b6b7ae2cd8be4aa491">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved111</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved111</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0bf8e7e39b473b9d83656444d92138ab">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved121</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved121</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="955868249f8f3616a63fda2815835da7">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved135</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved135</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="c64a6e74806632ebb19c30fcde59fe71">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved143</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved143</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="0f4c15abd6a63724a9eda3e97125f6b2">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved151</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved151</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="27b81b26cc003b59a8cae171658fda0c">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved159</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved159</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="b78416349ca635db8c071fe2d9a4821b">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved23</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/LHZCU_50ms_Group24_Reserved23</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </PHYSICAL-PROPS>
            </SYSTEM-SIGNAL>
            <SYSTEM-SIGNAL UUID="ac58541859d934108e3048685a3688fa">
              <SHORT-NAME>LHZCU_50ms_Group24_Reserved31</SHORT-NAME>
              <DYNAMIC-LENGTH>false</DYNAMIC-LENGTH>
              <PHYSICAL-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
