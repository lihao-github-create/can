<?xml version='1.0' encoding='UTF-8'?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00044.xsd">
  <ADMIN-DATA>
    <LANGUAGE>EN</LANGUAGE>
    <USED-LANGUAGES>
      <L-10 L="EN" xml:space="default" />
    </USED-LANGUAGES>
  </ADMIN-DATA>
  <AR-PACKAGES>
    <AR-PACKAGE UUID="1ccd0a82875f30ed860af6ec2e2f8a79">
      <SHORT-NAME>Communication</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="46ca2cc5c99d3b88907cbb21c6e8db22">
          <SHORT-NAME>Diagnostics</SHORT-NAME>
          <ELEMENTS>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6b1XOa505a3f19f25843c4b2dc6b000">
              <SHORT-NAME>Diag_BKPCANFD_Tester_FDR</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6f4XOa505a3f19f25843c4b2dc6f300">
              <SHORT-NAME>Diag_BKPCANFD_Tester_IMM</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6bdXOa505a3f19f25843c4b2dc6bc00">
              <SHORT-NAME>Diag_BKPCANFD_Tester_IPD</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
              <PHYSICAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnPhyReq_IPD</PHYSICAL-REQUEST-REF>
              <RESPONSE-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnPhyResp_IPD</RESPONSE-REF>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6c8XOa505a3f19f25843c4b2dc6c700">
              <SHORT-NAME>Diag_BKPCANFD_Tester_LFSDA</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6d3XOa505a3f19f25843c4b2dc6d200">
              <SHORT-NAME>Diag_BKPCANFD_Tester_LHRDA</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6deXOa505a3f19f25843c4b2dc6dd00">
              <SHORT-NAME>Diag_BKPCANFD_Tester_RFSDA</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
            <DIAGNOSTIC-CONNECTION UUID="Oa505a3f19f25843c4b2dc6e9XOa505a3f19f25843c4b2dc6e800">
              <SHORT-NAME>Diag_BKPCANFD_Tester_RHRDA</SHORT-NAME>
              <FUNCTIONAL-REQUEST-REFS>
                <FUNCTIONAL-REQUEST-REF DEST="TP-CONNECTION-IDENT">/Communication/TransportProtocol/BKPCANFDCANTpConfig/CanTpConnFuncReq</FUNCTIONAL-REQUEST-REF>
              </FUNCTIONAL-REQUEST-REFS>
            </DIAGNOSTIC-CONNECTION>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4b94d839b0413dc5b3fe05a0852848ad">
          <SHORT-NAME>Frames</SHORT-NAME>
          <ELEMENTS>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31ded7XOa505a3f19f25843c4b31ded600">
              <SHORT-NAME>BCM_BDCAN_100ms_FrP41</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31ded7xOa505a3f19f25843c4b31def000">
                  <SHORT-NAME>BCM_100ms_PDU41</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/BCM_100ms_PDU41</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f0b21XOa505a3f19f25843c4b2f0b2000">
              <SHORT-NAME>CCU_PTCANFD_100ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f0b21xOa505a3f19f25843c4b2f0b3a00">
                  <SHORT-NAME>CCU_100ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f0bf8XOa505a3f19f25843c4b2f0bf700">
              <SHORT-NAME>CCU_PTCANFD_100ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f0bf8xOa505a3f19f25843c4b2f0c1100">
                  <SHORT-NAME>CCU_100ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f0c22XOa505a3f19f25843c4b2f0c2100">
              <SHORT-NAME>CCU_PTCANFD_100ms_FrP07</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f0c22xOa505a3f19f25843c4b2f0c3f00">
                  <SHORT-NAME>CCU_100ms_PDU07</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU07</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f0c50XOa505a3f19f25843c4b2f0c4f00">
              <SHORT-NAME>CCU_PTCANFD_100ms_FrP11</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f0c50xOa505a3f19f25843c4b2f0c6d00">
                  <SHORT-NAME>CCU_100ms_PDU11</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/CCU_100ms_PDU11</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eb74XOa505a3f19f25843c4b35eb7300">
              <SHORT-NAME>CCU_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eb74xOa505a3f19f25843c4b35eb8e00">
                  <SHORT-NAME>NmPDU_PTCANFD_CCU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cc5eXOa505a3f19f25843c4b30cc5d00">
              <SHORT-NAME>DIAG_DTCInfo_ICBAD</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cc5exOa505a3f19f25843c4b30cc7400">
                  <SHORT-NAME>DIAG_DTCInfo_ICBAD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/DIAG_DTCInfo_ICBAD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326ddeXOa505a3f19f25843c4b326ddd00">
              <SHORT-NAME>DKMM_LHBDCANFD_Event_FrS03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326ddexOa505a3f19f25843c4b326df400">
                  <SHORT-NAME>DKMM_Sporadic_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/DKMM_Sporadic_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b360c43XOa505a3f19f25843c4b360c4200">
              <SHORT-NAME>Diag_BKPCANFD_FuncReq</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b360c43xOa505a3f19f25843c4b360c6200">
                  <SHORT-NAME>Diag_BKPCANFD_FuncReq</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_FuncReq</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b360cd1XOa505a3f19f25843c4b360cd000">
              <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b360cd1xOa505a3f19f25843c4b360cef00">
                  <SHORT-NAME>Diag_BKPCANFD_PhyReq_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_PhyReq_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b360d00XOa505a3f19f25843c4b360cff00">
              <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b360d00xOa505a3f19f25843c4b360d1e00">
                  <SHORT-NAME>Diag_BKPCANFD_PhyResp_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="N-PDU">/Communication/PDUs/Diag_BKPCANFD_PhyResp_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30204dXOa505a3f19f25843c4b30204c00">
              <SHORT-NAME>ECM_ERCANFD_100ms_ConFrP10</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30204dxOa505a3f19f25843c4b30206a00">
                  <SHORT-NAME>ECM_ERCANFD_100ms_container10</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/ECM_ERCANFD_100ms_container10</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3020a5XOa505a3f19f25843c4b3020a400">
              <SHORT-NAME>ECM_ERCANFD_10ms_FrP00</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3020a5xOa505a3f19f25843c4b3020be00">
                  <SHORT-NAME>ECM_010ms_PDU00</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_010ms_PDU00</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3058beXOa505a3f19f25843c4b3058bd00">
              <SHORT-NAME>ECM_ERCANFD_500ms_FrP14</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3058bexOa505a3f19f25843c4b3058d700">
                  <SHORT-NAME>ECM_500ms_PDU14</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_500ms_PDU14</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b34312eXOa505a3f19f25843c4b34312d00">
              <SHORT-NAME>ECM_PTCANFD_25ms_FrP36</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b34312exOa505a3f19f25843c4b34314b00">
                  <SHORT-NAME>ECM_25ms_PDU36</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_25ms_PDU36</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b34275dXOa505a3f19f25843c4b34275c00">
              <SHORT-NAME>ECM_PTCANFD_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b34275dxOa505a3f19f25843c4b34277600">
                  <SHORT-NAME>ECM_ZONE_050ms_PDU09</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_050ms_PDU09</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b342787XOa505a3f19f25843c4b34278600">
              <SHORT-NAME>ECM_PTCAN_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b342787xOa505a3f19f25843c4b3427a000">
                  <SHORT-NAME>ECM_ZONE_020ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ECM_ZONE_020ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2efa90XOa505a3f19f25843c4b2efa8f00">
              <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP01</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2efa90xOa505a3f19f25843c4b2efaae00">
                  <SHORT-NAME>EPS_ZONE_CHCANFD_10ms_Container01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/EPS_ZONE_CHCANFD_10ms_Container01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2efc50XOa505a3f19f25843c4b2efc4f00">
              <SHORT-NAME>EPS_CHCANFD_10ms_ConFrP05</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2efc50xOa505a3f19f25843c4b2efc6d00">
                  <SHORT-NAME>SAS_ZONE_CHCANFD_10ms_Container01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/SAS_ZONE_CHCANFD_10ms_Container01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b265XOa505a3f19f25843c4b33b26400">
              <SHORT-NAME>EPS_CHCANFD_20ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b265xOa505a3f19f25843c4b33b27e00">
                  <SHORT-NAME>EPS_20ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_20ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2efb11XOa505a3f19f25843c4b2efb1000">
              <SHORT-NAME>EPS_CHCANFD_CT_Tx</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2efb11xOa505a3f19f25843c4b2efb2700">
                  <SHORT-NAME>EPS_CHCANFD_CT_Tx</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/EPS_CHCANFD_CT_Tx</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ea03XOa505a3f19f25843c4b35ea0200">
              <SHORT-NAME>EPS_CHCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ea03xOa505a3f19f25843c4b35ea1e00">
                  <SHORT-NAME>NmPDU_CHCANFD_EPS</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2fc97cXOa505a3f19f25843c4b2fc97b00">
              <SHORT-NAME>ESS_PTCANFD_100ms_ConFrP19</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2fc97cxOa505a3f19f25843c4b2fc99900">
                  <SHORT-NAME>BMS_ZONE_PTCANFD_100ms_Container02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/BMS_ZONE_PTCANFD_100ms_Container02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eb48XOa505a3f19f25843c4b35eb4700">
              <SHORT-NAME>ESS_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eb48xOa505a3f19f25843c4b35eb6300">
                  <SHORT-NAME>NmPDU_PTCANFD_ESS</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b310411XOa505a3f19f25843c4b31041000">
              <SHORT-NAME>FDR_BKPCANFD_100ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b310411xOa505a3f19f25843c4b31042b00">
                  <SHORT-NAME>FDR_100ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FDR_100ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ed59XOa505a3f19f25843c4b35ed5800">
              <SHORT-NAME>FDR_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ed59xOa505a3f19f25843c4b35ed7300">
                  <SHORT-NAME>NmPDU_BKPCANFD_FDR</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30c9f7XOa505a3f19f25843c4b30c9f600">
              <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30c9f7xOa505a3f19f25843c4b30ca1400">
                  <SHORT-NAME>FVCM_100ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_100ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cb87XOa505a3f19f25843c4b30cb8600">
              <SHORT-NAME>FVCM_BKPCANFD_100ms_FrP05</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cb87xOa505a3f19f25843c4b30cba500">
                  <SHORT-NAME>FVCM_100ms_PDU05</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_100ms_PDU05</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30c9c8XOa505a3f19f25843c4b30c9c700">
              <SHORT-NAME>FVCM_BKPCANFD_10ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>12</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30c9c8xOa505a3f19f25843c4b30c9e600">
                  <SHORT-NAME>X0_0</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_10ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b127XOa505a3f19f25843c4b33b12600">
              <SHORT-NAME>FVCM_BKPCANFD_20ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b127xOa505a3f19f25843c4b33b14500">
                  <SHORT-NAME>FVCM_20ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/FVCM_20ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328431XOa505a3f19f25843c4b32843000">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP49</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328431xOa505a3f19f25843c4b32844a00">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU49</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU49</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3282e1XOa505a3f19f25843c4b3282e000">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP55</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3282e1xOa505a3f19f25843c4b3282fa00">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU55</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU55</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3283b3XOa505a3f19f25843c4b3283b200">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP58</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3283b3xOa505a3f19f25843c4b3283cc00">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU58</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU58</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32845bXOa505a3f19f25843c4b32845a00">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP59</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32845bxOa505a3f19f25843c4b32847400">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU59</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU59</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32830bXOa505a3f19f25843c4b32830a00">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP60</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32830bxOa505a3f19f25843c4b32832400">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU60</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU60</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328335XOa505a3f19f25843c4b32833400">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP61</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328335xOa505a3f19f25843c4b32834e00">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU61</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU61</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32835fXOa505a3f19f25843c4b32835e00">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP62</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32835fxOa505a3f19f25843c4b32837800">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU62</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU62</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328389XOa505a3f19f25843c4b32838800">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP63</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328389xOa505a3f19f25843c4b3283a200">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU63</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU63</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3283ddXOa505a3f19f25843c4b3283dc00">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP64</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3283ddxOa505a3f19f25843c4b3283f600">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU64</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU64</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328485XOa505a3f19f25843c4b32848400">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP65</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328485xOa505a3f19f25843c4b32849e00">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU65</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU65</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328407XOa505a3f19f25843c4b32840600">
              <SHORT-NAME>IAM_BKPCANFD_1000ms_FrP66</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328407xOa505a3f19f25843c4b32842000">
                  <SHORT-NAME>IAM_ZONE_1000ms_PDU66</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_1000ms_PDU66</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3273f5XOa505a3f19f25843c4b3273f400">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3273f5xOa505a3f19f25843c4b32740e00">
                  <SHORT-NAME>IAM_100ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3277ebXOa505a3f19f25843c4b3277ea00">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP06</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3277ebxOa505a3f19f25843c4b32780400">
                  <SHORT-NAME>IAM_100ms_PDU06</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU06</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32719dXOa505a3f19f25843c4b32719c00">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP07</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32719dxOa505a3f19f25843c4b3271b600">
                  <SHORT-NAME>IAM_100ms_PDU07</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU07</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326e5dXOa505a3f19f25843c4b326e5c00">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP08</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326e5dxOa505a3f19f25843c4b326e7600">
                  <SHORT-NAME>IAM_100ms_PDU08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327a13XOa505a3f19f25843c4b327a1200">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP34</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327a13xOa505a3f19f25843c4b327a2c00">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU34</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU34</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326e33XOa505a3f19f25843c4b326e3200">
              <SHORT-NAME>IAM_CONNCANFD_100ms_FrP40</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326e33xOa505a3f19f25843c4b326e4c00">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU40</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU40</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328722XOa505a3f19f25843c4b32872100">
              <SHORT-NAME>IAM_CONNCANFD_20ms_FrP32</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328722xOa505a3f19f25843c4b32873f00">
                  <SHORT-NAME>IAM_20ms_PDU32</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_20ms_PDU32</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327b69XOa505a3f19f25843c4b327b6800">
              <SHORT-NAME>IAM_CONNCANFD_Event_FrS04</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327b69xOa505a3f19f25843c4b327b8300">
                  <SHORT-NAME>IAM_Sporadic_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_Sporadic_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3286a3XOa505a3f19f25843c4b3286a200">
              <SHORT-NAME>IAM_CONNCAN_100ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3286a3xOa505a3f19f25843c4b3286bc00">
                  <SHORT-NAME>IAM_100ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327a3dXOa505a3f19f25843c4b327a3c00">
              <SHORT-NAME>IAM_CONNCAN_100ms_FrP18</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327a3dxOa505a3f19f25843c4b327a5600">
                  <SHORT-NAME>IAM_100ms_PDU18</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU18</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3261f1XOa505a3f19f25843c4b3261f000">
              <SHORT-NAME>IAM_CONNCAN_100ms_FrS21</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3261f1xOa505a3f19f25843c4b32620a00">
                  <SHORT-NAME>IAM_100ms_PDU21</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_100ms_PDU21</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327e0eXOa505a3f19f25843c4b327e0d00">
              <SHORT-NAME>IAM_RHBKBCANFD_100ms_FrP57</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327e0exOa505a3f19f25843c4b327e2700">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU57</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU57</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3279e9XOa505a3f19f25843c4b3279e800">
              <SHORT-NAME>IAM_RZCUCANFD_100ms_FrP35</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3279e9xOa505a3f19f25843c4b327a0200">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU35</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU35</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327966XOa505a3f19f25843c4b32796500">
              <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327966xOa505a3f19f25843c4b32797f00">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU13</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU13</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327aedXOa505a3f19f25843c4b327aec00">
              <SHORT-NAME>IAM_ZONE_CONNCANFD_100ms_FrP56</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327aedxOa505a3f19f25843c4b327b0600">
                  <SHORT-NAME>IAM_ZONE_100ms_PDU56</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IAM_ZONE_100ms_PDU56</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f99afXOa505a3f19f25843c4b2f99ae00">
              <SHORT-NAME>IBS_CHCANFD_100ms_FrP15</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f99afxOa505a3f19f25843c4b2f99c900">
                  <SHORT-NAME>IBS_100ms_PDU15</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_100ms_PDU15</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9bf5XOa505a3f19f25843c4b2f9bf400">
              <SHORT-NAME>IBS_CHCANFD_10ms_ConFrP04</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9bf5xOa505a3f19f25843c4b2f9c1200">
                  <SHORT-NAME>IBS_CHCANFD_10ms_Container01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IBS_CHCANFD_10ms_Container01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f99daXOa505a3f19f25843c4b2f99d900">
              <SHORT-NAME>IBS_CHCANFD_10ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f99daxOa505a3f19f25843c4b2f99f500">
                  <SHORT-NAME>IBS_10ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_10ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9a06XOa505a3f19f25843c4b2f9a0500">
              <SHORT-NAME>IBS_CHCANFD_10ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9a06xOa505a3f19f25843c4b2f9a2100">
                  <SHORT-NAME>IBS_10ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_10ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9b04XOa505a3f19f25843c4b2f9b0300">
              <SHORT-NAME>IBS_CHCANFD_20ms_ConFrP10</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9b04xOa505a3f19f25843c4b2f9b2100">
                  <SHORT-NAME>IBS_CHCANFD_20ms_Container01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IBS_CHCANFD_20ms_Container01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9a32XOa505a3f19f25843c4b2f9a3100">
              <SHORT-NAME>IBS_CHCANFD_20ms_FrP07</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9a32xOa505a3f19f25843c4b2f9a4b00">
                  <SHORT-NAME>IBS_20ms_PDU07</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU07</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9a5cXOa505a3f19f25843c4b2f9a5b00">
              <SHORT-NAME>IBS_CHCANFD_20ms_FrP08</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9a5cxOa505a3f19f25843c4b2f9a7500">
                  <SHORT-NAME>IBS_20ms_PDU08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9a86XOa505a3f19f25843c4b2f9a8500">
              <SHORT-NAME>IBS_CHCANFD_20ms_FrP09</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9a86xOa505a3f19f25843c4b2f9a9f00">
                  <SHORT-NAME>IBS_20ms_PDU09</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU09</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9ab0XOa505a3f19f25843c4b2f9aaf00">
              <SHORT-NAME>IBS_CHCANFD_20ms_FrP11</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9ab0xOa505a3f19f25843c4b2f9ac900">
                  <SHORT-NAME>IBS_20ms_PDU11</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU11</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f9adaXOa505a3f19f25843c4b2f9ad900">
              <SHORT-NAME>IBS_CHCANFD_20ms_FrP12</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f9adaxOa505a3f19f25843c4b2f9af300">
                  <SHORT-NAME>IBS_20ms_PDU12</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU12</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ea2fXOa505a3f19f25843c4b35ea2e00">
              <SHORT-NAME>IBS_CHCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ea2fxOa505a3f19f25843c4b35ea4900">
                  <SHORT-NAME>NmPDU_CHCANFD_IBS</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2fb5e9XOa505a3f19f25843c4b2fb5e800">
              <SHORT-NAME>IBS_SFCANFD_20ms_FrP26</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2fb5e9xOa505a3f19f25843c4b2fb60200">
                  <SHORT-NAME>IBS_20ms_PDU26</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_20ms_PDU26</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f15cXOa505a3f19f25843c4b35f15b00">
              <SHORT-NAME>IBS_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f15cxOa505a3f19f25843c4b35f17700">
                  <SHORT-NAME>NmPDU_SFCANFD_IBS</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2fb668XOa505a3f19f25843c4b2fb66700">
              <SHORT-NAME>IBS_ZONE_CHCANFD_20ms_FrP08</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2fb668xOa505a3f19f25843c4b2fb68100">
                  <SHORT-NAME>IBS_ZONE_20ms_PDU08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IBS_ZONE_20ms_PDU08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30caa7XOa505a3f19f25843c4b30caa600">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP27</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30caa7xOa505a3f19f25843c4b30cac400">
                  <SHORT-NAME>ICBAD_100ms_PDU27</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU27</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326d5bXOa505a3f19f25843c4b326d5a00">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP29_NoSecOC</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326d5bxOa505a3f19f25843c4b326d7400">
                  <SHORT-NAME>ICBAD_100ms_PDU29</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU29</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cb2dXOa505a3f19f25843c4b30cb2c00">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP34</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cb2dxOa505a3f19f25843c4b30cb4700">
                  <SHORT-NAME>ICBAD_100ms_PDU34</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU34</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327cb7XOa505a3f19f25843c4b327cb600">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP36</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327cb7xOa505a3f19f25843c4b327cd400">
                  <SHORT-NAME>ICBAD_100ms_PDU36</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU36</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30ca7dXOa505a3f19f25843c4b30ca7c00">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP37</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30ca7dxOa505a3f19f25843c4b30ca9600">
                  <SHORT-NAME>ICBAD_100ms_PDU37</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU37</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cb58XOa505a3f19f25843c4b30cb5700">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP38</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cb58xOa505a3f19f25843c4b30cb7600">
                  <SHORT-NAME>ICBAD_100ms_PDU38</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU38</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327e38XOa505a3f19f25843c4b327e3700">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP39</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327e38xOa505a3f19f25843c4b327e5100">
                  <SHORT-NAME>ICBAD_100ms_PDU39</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU39</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d6a8XOa505a3f19f25843c4b31d6a700">
              <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP44</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d6a8xOa505a3f19f25843c4b31d6c500">
                  <SHORT-NAME>ICBAD_100ms_PDU44</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU44</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3066a9XOa505a3f19f25843c4b3066a800">
              <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3066a9xOa505a3f19f25843c4b3066c200">
                  <SHORT-NAME>ICBAD_20ms_PDU07</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU07</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328010XOa505a3f19f25843c4b32800f00">
              <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP09</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328010xOa505a3f19f25843c4b32802900">
                  <SHORT-NAME>ICBAD_20ms_PDU09</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU09</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cb03XOa505a3f19f25843c4b30cb0200">
              <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cb03xOa505a3f19f25843c4b30cb1c00">
                  <SHORT-NAME>ICBAD_20ms_PDU46</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU46</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cad5XOa505a3f19f25843c4b30cad400">
              <SHORT-NAME>ICBAD_BKPCANFD_50ms_FrP17</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cad5xOa505a3f19f25843c4b30caf200">
                  <SHORT-NAME>ICBAD_50ms_PDU17</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_50ms_PDU17</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b354317XOa505a3f19f25843c4b35431600">
              <SHORT-NAME>ICBAD_CHCANFD_100ms_FrP25</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b354317xOa505a3f19f25843c4b35433600">
                  <SHORT-NAME>ICBAD_100ms_PDU25</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU25</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b353eebXOa505a3f19f25843c4b353eea00">
              <SHORT-NAME>ICBAD_CHCANFD_10ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b353eebxOa505a3f19f25843c4b353f0a00">
                  <SHORT-NAME>ICBAD_10ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_10ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d989XOa505a3f19f25843c4b31d98800">
              <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP08</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d989xOa505a3f19f25843c4b31d9a300">
                  <SHORT-NAME>ICBAD_20ms_PDU08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306988XOa505a3f19f25843c4b30698700">
              <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306988xOa505a3f19f25843c4b3069a100">
                  <SHORT-NAME>ICBAD_20ms_PDU13</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU13</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30657bXOa505a3f19f25843c4b30657a00">
              <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP16</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30657bxOa505a3f19f25843c4b30659400">
                  <SHORT-NAME>ICBAD_20ms_PDU16</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU16</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cbb6XOa505a3f19f25843c4b30cbb500">
              <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP48</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cbb6xOa505a3f19f25843c4b30cbcf00">
                  <SHORT-NAME>X0_0</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU48</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cc34XOa505a3f19f25843c4b30cc3300">
              <SHORT-NAME>ICBAD_CHCANFD_Event_FrS03</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cc34xOa505a3f19f25843c4b30cc4d00">
                  <SHORT-NAME>X0_0</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_Sporadic_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30667bXOa505a3f19f25843c4b30667a00">
              <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP05</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30667bxOa505a3f19f25843c4b30669800">
                  <SHORT-NAME>ICBAD_20ms_PDU05</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU05</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30695eXOa505a3f19f25843c4b30695d00">
              <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30695exOa505a3f19f25843c4b30697700">
                  <SHORT-NAME>ICBAD_20ms_PDU12</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU12</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326cd1XOa505a3f19f25843c4b326cd000">
              <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP15_NoSecOC</SHORT-NAME>
              <FRAME-LENGTH>12</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326cd1xOa505a3f19f25843c4b326cee00">
                  <SHORT-NAME>ICBAD_20ms_PDU15</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_20ms_PDU15</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b333cf5XOa505a3f19f25843c4b333cf400">
              <SHORT-NAME>ICBAD_RZCUCANFD_50ms_FrP21</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b333cf5xOa505a3f19f25843c4b333d1200">
                  <SHORT-NAME>ICBAD_50ms_PDU21</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_50ms_PDU21</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327d13XOa505a3f19f25843c4b327d1200">
              <SHORT-NAME>ICBAD_SecOC_ComKeyResp</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327d13xOa505a3f19f25843c4b327d2900">
                  <SHORT-NAME>ICBAD_SecOCComKeyResp_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCComKeyResp_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327c14XOa505a3f19f25843c4b327c1300">
              <SHORT-NAME>ICBAD_SecOC_Log</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327c14xOa505a3f19f25843c4b327c2a00">
                  <SHORT-NAME>ICBAD_SecOCLog_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_SecOCLog_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cbe0XOa505a3f19f25843c4b30cbdf00">
              <SHORT-NAME>ICBAD_ZONE_CHCANFD_10ms_FrP20</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cbe0xOa505a3f19f25843c4b30cbf900">
                  <SHORT-NAME>X0_0</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_10ms_PDU20</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30cc0aXOa505a3f19f25843c4b30cc0900">
              <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30cc0axOa505a3f19f25843c4b30cc2300">
                  <SHORT-NAME>ICBAD_ZONE_20ms_PDU13</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_ZONE_20ms_PDU13</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327e90XOa505a3f19f25843c4b327e8f00">
              <SHORT-NAME>ICBVC_BKPCANFD_1000ms_FrP50</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327e90xOa505a3f19f25843c4b327ea900">
                  <SHORT-NAME>ICBVC_1000ms_PDU50</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_1000ms_PDU50</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30677cXOa505a3f19f25843c4b30677b00">
              <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30677cxOa505a3f19f25843c4b30679900">
                  <SHORT-NAME>ICBVC_100ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306a84XOa505a3f19f25843c4b306a8300">
              <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP17</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306a84xOa505a3f19f25843c4b306a9d00">
                  <SHORT-NAME>ICBVC_100ms_PDU17</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU17</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327e62XOa505a3f19f25843c4b327e6100">
              <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP25</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327e62xOa505a3f19f25843c4b327e7f00">
                  <SHORT-NAME>ICBVC_100ms_PDU25</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU25</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326e05XOa505a3f19f25843c4b326e0400">
              <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP31</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326e05xOa505a3f19f25843c4b326e2200">
                  <SHORT-NAME>ICBVC_100ms_PDU31</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU31</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3065a5XOa505a3f19f25843c4b3065a400">
              <SHORT-NAME>ICBVC_BKPCANFD_100ms_FrP35</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3065a5xOa505a3f19f25843c4b3065be00">
                  <SHORT-NAME>ICBVC_100ms_PDU35</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU35</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b185XOa505a3f19f25843c4b33b18400">
              <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP11</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b185xOa505a3f19f25843c4b33b19f00">
                  <SHORT-NAME>ICBVC_50ms_PDU11</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU11</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b5d9XOa505a3f19f25843c4b33b5d800">
              <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP13</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b5d9xOa505a3f19f25843c4b33b5f600">
                  <SHORT-NAME>ICBVC_50ms_PDU13</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU13</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b333c4cXOa505a3f19f25843c4b333c4b00">
              <SHORT-NAME>ICBVC_BKPCANFD_50ms_FrP55</SHORT-NAME>
              <FRAME-LENGTH>12</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b333c4cxN20000011a02779c9f44252d00">
                  <SHORT-NAME>ICBVC_50ms_PDU55</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU55</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326db3XOa505a3f19f25843c4b326db200">
              <SHORT-NAME>ICBVC_BKPCANFD_Event_FrS138</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326db3xOa505a3f19f25843c4b326dcd00">
                  <SHORT-NAME>ICBVC_Sporadic_PDU138</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_Sporadic_PDU138</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f864cXOa505a3f19f25843c4b2f864b00">
              <SHORT-NAME>ICBVC_FOTASts_100ms_FrP47</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f864cxOa505a3f19f25843c4b2f866500">
                  <SHORT-NAME>ICBVC_100ms_PDU47</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU47</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306a5aXOa505a3f19f25843c4b306a5900">
              <SHORT-NAME>ICBVC_INFOCANFD_250ms_FrP52</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306a5axOa505a3f19f25843c4b306a7300">
                  <SHORT-NAME>ICBVC_250ms_PDU52</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_250ms_PDU52</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3066fdXOa505a3f19f25843c4b3066fc00">
              <SHORT-NAME>ICBVC_RHBKBCANFD_500ms_FrP67</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3066fdxOa505a3f19f25843c4b30671600">
                  <SHORT-NAME>ICBVC_500ms_PDU67</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_500ms_PDU67</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b4ddXOa505a3f19f25843c4b33b4dc00">
              <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP19</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b4ddxOa505a3f19f25843c4b33b4f600">
                  <SHORT-NAME>ICBVC_100ms_PDU19</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU19</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3068b2XOa505a3f19f25843c4b3068b100">
              <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP27</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3068b2xOa505a3f19f25843c4b3068cb00">
                  <SHORT-NAME>ICBVC_100ms_PDU27</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU27</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306727XOa505a3f19f25843c4b30672600">
              <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP48</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306727xOa505a3f19f25843c4b30674100">
                  <SHORT-NAME>ICBVC_100ms_PDU48</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU48</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3069b2XOa505a3f19f25843c4b3069b100">
              <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP80</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3069b2xOa505a3f19f25843c4b3069cb00">
                  <SHORT-NAME>ICBVC_100ms_PDU80</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU80</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306b8aXOa505a3f19f25843c4b306b8900">
              <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP50</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306b8axOa505a3f19f25843c4b306ba300">
                  <SHORT-NAME>ICBVC_200ms_PDU50</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU50</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3069dcXOa505a3f19f25843c4b3069db00">
              <SHORT-NAME>ICBVC_RZCUCANFD_200ms_FrP79</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3069dcxOa505a3f19f25843c4b3069f500">
                  <SHORT-NAME>ICBVC_200ms_PDU79</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_200ms_PDU79</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b507XOa505a3f19f25843c4b33b50600">
              <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP00</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b507xOa505a3f19f25843c4b33b52000">
                  <SHORT-NAME>ICBVC_20ms_PDU00</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU00</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306a06XOa505a3f19f25843c4b306a0500">
              <SHORT-NAME>ICBVC_RZCUCANFD_20ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306a06xOa505a3f19f25843c4b306a1f00">
                  <SHORT-NAME>ICBVC_20ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_20ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3274d0XOa505a3f19f25843c4b3274cf00">
              <SHORT-NAME>ICBVC_SecOC_ComKeyReq</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3274d0xOa505a3f19f25843c4b3274e600">
                  <SHORT-NAME>ICBVC_SecOCComKeyReq_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_SecOCComKeyReq_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b333c7aXOa505a3f19f25843c4b333c7900">
              <SHORT-NAME>ICBVC_SecOC_SyncMsg</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b333c7axOa505a3f19f25843c4b333c9000">
                  <SHORT-NAME>ICBVC_SecOC_SyncMsg</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="SECURED-I-PDU">/Communication/PDUs/SecuredIPdu_ICC_SecOC_SyncMsg</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306651XOa505a3f19f25843c4b30665000">
              <SHORT-NAME>ICB_BKBCANFD_100ms_FrP146</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306651xOa505a3f19f25843c4b30666a00">
                  <SHORT-NAME>ICB_100ms_PDU146</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU146</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3065f9XOa505a3f19f25843c4b3065f800">
              <SHORT-NAME>ICB_BKBCANFD_100ms_FrP147</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3065f9xOa505a3f19f25843c4b30661200">
                  <SHORT-NAME>ICB_100ms_PDU147</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU147</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327ce5XOa505a3f19f25843c4b327ce400">
              <SHORT-NAME>ICB_BKBCANFD_100ms_FrP221</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327ce5xOa505a3f19f25843c4b327d0200">
                  <SHORT-NAME>ICB_100ms_PDU221</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU221</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306522XOa505a3f19f25843c4b30652100">
              <SHORT-NAME>ICB_BKPCANFD_100ms_FrP159</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306522xOa505a3f19f25843c4b30654000">
                  <SHORT-NAME>ICB_100ms_PDU159</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU159</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32793cXOa505a3f19f25843c4b32793b00">
              <SHORT-NAME>ICB_BKPCANFD_100ms_FrP82</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32793cxOa505a3f19f25843c4b32795500">
                  <SHORT-NAME>ICB_100ms_PDU82</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_100ms_PDU82</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31e002XOa505a3f19f25843c4b31e00100">
              <SHORT-NAME>ICB_BKPCANFD_500ms_FrP229</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31e002xOa505a3f19f25843c4b31e01f00">
                  <SHORT-NAME>ICB_500ms_PDU229</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_500ms_PDU229</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b156XOa505a3f19f25843c4b33b15500">
              <SHORT-NAME>ICB_BKPCANFD_50ms_FrP158</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b156xOa505a3f19f25843c4b33b17400">
                  <SHORT-NAME>ICBVC_30ms_PDU158</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU158</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327be9XOa505a3f19f25843c4b327be800">
              <SHORT-NAME>ICB_CONNCANFD_Event_FrS67</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327be9xOa505a3f19f25843c4b327c0300">
                  <SHORT-NAME>ICB_Sporadic_PDU67</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_Sporadic_PDU67</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b306884XOa505a3f19f25843c4b30688300">
              <SHORT-NAME>ICB_ZONE_BDCAN_100ms_FrP00</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b306884xOa505a3f19f25843c4b3068a100">
                  <SHORT-NAME>ICB_ZONE_100ms_PDU00</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICB_ZONE_100ms_PDU00</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b350ed6XOa505a3f19f25843c4b350ed500">
              <SHORT-NAME>IMM_BKPCANFD_50ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b350ed6xOa505a3f19f25843c4b350ef600">
                  <SHORT-NAME>IMM_50ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b357426XOa505a3f19f25843c4b35742500">
              <SHORT-NAME>IMM_BKPCANFD_50ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b357426xOa505a3f19f25843c4b35744600">
                  <SHORT-NAME>IMM_50ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IMM_50ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ee30XOa505a3f19f25843c4b35ee2f00">
              <SHORT-NAME>IMM_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ee30xOa505a3f19f25843c4b35ee4a00">
                  <SHORT-NAME>NmPDU_BKPCANFD_IMM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3541afXOa505a3f19f25843c4b3541ae00">
              <SHORT-NAME>IPD_BKBCANFD_EvtInfo</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3541afxOa505a3f19f25843c4b3541cd00">
                  <SHORT-NAME>IPD_BKBCANFD_EvtInfo</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_BKBCANFD_EvtInfo</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327fe2XOa505a3f19f25843c4b327fe100">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP124</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327fe2xOa505a3f19f25843c4b327fff00">
                  <SHORT-NAME>IPD_100ms_PDU124</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU124</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32815dXOa505a3f19f25843c4b32815c00">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP127</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32815dxOa505a3f19f25843c4b32817a00">
                  <SHORT-NAME>IPD_100ms_PDU127</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU127</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328064XOa505a3f19f25843c4b32806300">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP128</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328064xOa505a3f19f25843c4b32808100">
                  <SHORT-NAME>IPD_100ms_PDU128</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU128</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b353e02XOa505a3f19f25843c4b353e0100">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP35</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b353e02xOa505a3f19f25843c4b353e2400">
                  <SHORT-NAME>IPD_100ms_PDU35</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU35</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31e285XOa505a3f19f25843c4b31e28400">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP50</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31e285xOa505a3f19f25843c4b31e2a400">
                  <SHORT-NAME>IPD_100ms_PDU50</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU50</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327d3aXOa505a3f19f25843c4b327d3900">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP58</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327d3axOa505a3f19f25843c4b327d5700">
                  <SHORT-NAME>IPD_100ms_PDU58</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU58</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3278bdXOa505a3f19f25843c4b3278bc00">
              <SHORT-NAME>IPD_BKPCANFD_100ms_FrP61</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3278bdxOa505a3f19f25843c4b3278da00">
                  <SHORT-NAME>IPD_100ms_PDU61</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU61</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b354377XOa505a3f19f25843c4b35437600">
              <SHORT-NAME>IPD_BKPCANFD_100ms_P31</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b354377xOa505a3f19f25843c4b35439600">
                  <SHORT-NAME>ICBAD_100ms_PDU31</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBAD_100ms_PDU31</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32716fXOa505a3f19f25843c4b32716e00">
              <SHORT-NAME>IPD_BKPCANFD_10ms_FrP59</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32716fxOa505a3f19f25843c4b32718c00">
                  <SHORT-NAME>IPD_10ms_PDU59</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_10ms_PDU59</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d650XOa505a3f19f25843c4b31d64f00">
              <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d650xOa505a3f19f25843c4b31d66900">
                  <SHORT-NAME>IPD_20ms_PDU43</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU43</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326ca2XOa505a3f19f25843c4b326ca100">
              <SHORT-NAME>IPD_BKPCANFD_20ms_FrP60</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326ca2xOa505a3f19f25843c4b326cc000">
                  <SHORT-NAME>IPD_20ms_PDU60</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU60</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327d8fXOa505a3f19f25843c4b327d8e00">
              <SHORT-NAME>IPD_BKPCANFD_50ms_FrP14</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327d8fxOa505a3f19f25843c4b327dac00">
                  <SHORT-NAME>IPD_50ms_PDU14</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU14</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N200000119f5e170b8e1f8d6XN200000119f5e170b8e1f8d000">
              <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N200000119f5e170b8e1f8d6xN20000011a02779c9f444b2700">
                  <SHORT-NAME>IPD_50ms_PDU49</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU49</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31e085XOa505a3f19f25843c4b31e08400">
              <SHORT-NAME>IPD_BKPCANFD_50ms_FrP62</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31e085xOa505a3f19f25843c4b31e0a200">
                  <SHORT-NAME>IPD_50ms_PDU62</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_50ms_PDU62</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b315f70XOa505a3f19f25843c4b315f6f00">
              <SHORT-NAME>IPD_BKPCANFD_Event_FrS01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b315f70xOa505a3f19f25843c4b315f8700">
                  <SHORT-NAME>IPD_Sporadic_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327c8cXOa505a3f19f25843c4b327c8b00">
              <SHORT-NAME>IPD_BKPCANFD_Event_FrS13</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327c8cxOa505a3f19f25843c4b327ca600">
                  <SHORT-NAME>IPD_Sporadic_PDU13</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU13</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327c65XOa505a3f19f25843c4b327c6400">
              <SHORT-NAME>IPD_BKPCANFD_Event_FrS35</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327c65xOa505a3f19f25843c4b327c7b00">
                  <SHORT-NAME>IPD_Sporadic_PDU35</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_Sporadic_PDU35</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ed2eXOa505a3f19f25843c4b35ed2d00">
              <SHORT-NAME>IPD_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ed2exOa505a3f19f25843c4b35ed4800">
                  <SHORT-NAME>NmPDU_BKPCANFD_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32818bXOa505a3f19f25843c4b32818a00">
              <SHORT-NAME>IPD_CHCANFD_100ms_FrP130</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32818bxOa505a3f19f25843c4b3281a800">
                  <SHORT-NAME>IPD_100ms_PDU130</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU130</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ea85XOa505a3f19f25843c4b35ea8400">
              <SHORT-NAME>IPD_CHCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ea85xOa505a3f19f25843c4b35ea9f00">
                  <SHORT-NAME>NmPDU_CHCANFD_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30ca25XOa505a3f19f25843c4b30ca2400">
              <SHORT-NAME>IPD_PTCANFD_100ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30ca25xOa505a3f19f25843c4b30ca3e00">
                  <SHORT-NAME>IPD_100ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b327c3bXOa505a3f19f25843c4b327c3a00">
              <SHORT-NAME>IPD_PTCANFD_100ms_FrP16</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b327c3bxOa505a3f19f25843c4b327c5400">
                  <SHORT-NAME>IPD_100ms_PDU16</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_100ms_PDU16</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b34315cXOa505a3f19f25843c4b34315b00">
              <SHORT-NAME>IPD_PTCANFD_20ms_FrP64</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b34315cxOa505a3f19f25843c4b34317900">
                  <SHORT-NAME>IPD_20ms_PDU64</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU64</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3573caXOa505a3f19f25843c4b3573c900">
              <SHORT-NAME>IPD_PTCANFD_20ms_FrP67</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3573caxOa505a3f19f25843c4b3573e900">
                  <SHORT-NAME>IPD_20ms_PDU67</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/IPD_20ms_PDU67</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ebcaXOa505a3f19f25843c4b35ebc900">
              <SHORT-NAME>IPD_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ebcaxOa505a3f19f25843c4b35ebe400">
                  <SHORT-NAME>NmPDU_PTCANFD_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f188XOa505a3f19f25843c4b35f18700">
              <SHORT-NAME>IPD_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f188xOa505a3f19f25843c4b35f1a200">
                  <SHORT-NAME>NmPDU_SFCANFD_IPD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ed84XOa505a3f19f25843c4b35ed8300">
              <SHORT-NAME>LFSDA_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ed84xOa505a3f19f25843c4b35ed9e00">
                  <SHORT-NAME>NmPDU_BKPCANFD_LFSDA</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35edafXOa505a3f19f25843c4b35edae00">
              <SHORT-NAME>LHRDA_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35edafxOa505a3f19f25843c4b35edc900">
                  <SHORT-NAME>NmPDU_BKPCANFD_LHRDA</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d9dfXOa505a3f19f25843c4b31d9de00">
              <SHORT-NAME>LHZCU_BKBCANFD_100ms_FrP30</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d9dfxOa505a3f19f25843c4b31d9fc00">
                  <SHORT-NAME>LHZCU_100ms_PDU30</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU30</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f3808XOa505a3f19f25843c4b2f380700">
              <SHORT-NAME>LHZCU_BKBCANFD_10ms_FrP32</SHORT-NAME>
              <FRAME-LENGTH>12</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f3808xOa505a3f19f25843c4b2f382700">
                  <SHORT-NAME>LHZCU_10ms_PDU32</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU32</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f34adXOa505a3f19f25843c4b2f34ac00">
              <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f34adxOa505a3f19f25843c4b2f34c600">
                  <SHORT-NAME>LHZCU_400ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b333acfXOa505a3f19f25843c4b333ace00">
              <SHORT-NAME>LHZCU_BKBCANFD_400ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b333acfxOa505a3f19f25843c4b333ae800">
                  <SHORT-NAME>LHZCU_400ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f34d7XOa505a3f19f25843c4b2f34d600">
              <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP24</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f34d7xOa505a3f19f25843c4b2f34f400">
                  <SHORT-NAME>LHZCU_50ms_PDU24</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU24</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f3505XOa505a3f19f25843c4b2f350400">
              <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP34</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f3505xOa505a3f19f25843c4b2f352200">
                  <SHORT-NAME>LHZCU_50ms_PDU34</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU34</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b350f07XOa505a3f19f25843c4b350f0600">
              <SHORT-NAME>LHZCU_BKBCANFD_50ms_FrP58</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b350f07xOa505a3f19f25843c4b350f2600">
                  <SHORT-NAME>LHZCU_50ms_PDU58</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU58</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f3482XOa505a3f19f25843c4b2f348100">
              <SHORT-NAME>LHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f3482xOa505a3f19f25843c4b2f349c00">
                  <SHORT-NAME>LHZCU_ICBVC_50ms_PDU14</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_ICBVC_50ms_PDU14</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f375fXOa505a3f19f25843c4b2f375e00">
              <SHORT-NAME>LHZCU_LHBKBCANFDF_400ms_FrP18</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f375fxOa505a3f19f25843c4b2f377800">
                  <SHORT-NAME>LHZCU_400ms_PDU18</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_400ms_PDU18</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f358cXOa505a3f19f25843c4b2f358b00">
              <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP14</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f358cxOa505a3f19f25843c4b2f35a500">
                  <SHORT-NAME>LHZCU_100ms_PDU14</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU14</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f35b6XOa505a3f19f25843c4b2f35b500">
              <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP15</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f35b6xOa505a3f19f25843c4b2f35cf00">
                  <SHORT-NAME>LHZCU_100ms_PDU15</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU15</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f35e0XOa505a3f19f25843c4b2f35df00">
              <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP16</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f35e0xOa505a3f19f25843c4b2f35fd00">
                  <SHORT-NAME>LHZCU_100ms_PDU16</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU16</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f360eXOa505a3f19f25843c4b2f360d00">
              <SHORT-NAME>LHZCU_LHBKBCANFD_100ms_FrP22</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f360exOa505a3f19f25843c4b2f362700">
                  <SHORT-NAME>LHZCU_100ms_PDU22</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_100ms_PDU22</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f3638XOa505a3f19f25843c4b2f363700">
              <SHORT-NAME>LHZCU_LHBKBCANFD_10ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f3638xOa505a3f19f25843c4b2f365200">
                  <SHORT-NAME>LHZCU_10ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_10ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f368dXOa505a3f19f25843c4b2f368c00">
              <SHORT-NAME>LHZCU_LHBKBCANFD_20ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f368dxOa505a3f19f25843c4b2f36a600">
                  <SHORT-NAME>LHZCU_20ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_20ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f36b7XOa505a3f19f25843c4b2f36b600">
              <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f36b7xOa505a3f19f25843c4b2f36d000">
                  <SHORT-NAME>LHZCU_50ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f370bXOa505a3f19f25843c4b2f370a00">
              <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP06</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f370bxOa505a3f19f25843c4b2f372400">
                  <SHORT-NAME>LHZCU_50ms_PDU06</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU06</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f3735XOa505a3f19f25843c4b2f373400">
              <SHORT-NAME>LHZCU_LHBKBCANFD_50ms_FrP08</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f3735xOa505a3f19f25843c4b2f374e00">
                  <SHORT-NAME>LHZCU_50ms_PDU08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/LHZCU_50ms_PDU08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ecccXOa505a3f19f25843c4b35eccb00">
              <SHORT-NAME>LVBM_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ecccxOa505a3f19f25843c4b35ece600">
                  <SHORT-NAME>NmPDU_PTCANFD_LVBM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ebf5XOa505a3f19f25843c4b35ebf400">
              <SHORT-NAME>MMCU_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ebf5xOa505a3f19f25843c4b35ec0f00">
                  <SHORT-NAME>NmPDU_PTCANFD_MMCU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f2b39XOa505a3f19f25843c4b2f2b3800">
              <SHORT-NAME>PEU_PTCANFD_10ms_FrP25</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f2b39xOa505a3f19f25843c4b2f2b5800">
                  <SHORT-NAME>PEU_10ms_PDU25</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PEU_10ms_PDU25</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eca1XOa505a3f19f25843c4b35eca000">
              <SHORT-NAME>PEU_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eca1xOa505a3f19f25843c4b35ecbb00">
                  <SHORT-NAME>NmPDU_PTCANFD_PEU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f234XOa505a3f19f25843c4b35f23300">
              <SHORT-NAME>PEU_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f234xOa505a3f19f25843c4b35f24e00">
                  <SHORT-NAME>NmPDU_SFCANFD_PEU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326d2dXOa505a3f19f25843c4b326d2c00">
              <SHORT-NAME>PICM_PTCANFD_100ms_FrP06</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326d2dxOa505a3f19f25843c4b326d4a00">
                  <SHORT-NAME>PICM_100ms_PDU06</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICM_100ms_PDU06</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ec20XOa505a3f19f25843c4b35ec1f00">
              <SHORT-NAME>PICM_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ec20xOa505a3f19f25843c4b35ec3a00">
                  <SHORT-NAME>NmPDU_PTCANFD_PICM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f1b3XOa505a3f19f25843c4b35f1b200">
              <SHORT-NAME>PICM_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f1b3xOa505a3f19f25843c4b35f1cd00">
                  <SHORT-NAME>NmPDU_SFCANFD_PICM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b302123XOa505a3f19f25843c4b30212200">
              <SHORT-NAME>PICU_PTCANFD_10ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b302123xOa505a3f19f25843c4b30214000">
                  <SHORT-NAME>PICU_10ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b30217fXOa505a3f19f25843c4b30217e00">
              <SHORT-NAME>PICU_PTCANFD_20ms_FrP11</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b30217fxOa505a3f19f25843c4b30219c00">
                  <SHORT-NAME>PICU_20ms_PDU11</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_20ms_PDU11</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b337XOa505a3f19f25843c4b33b33600">
              <SHORT-NAME>PICU_PTEXTDCAN_10ms_FrP23</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b337xOa505a3f19f25843c4b33b35000">
                  <SHORT-NAME>PICU_10ms_PDU23</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/PICU_10ms_PDU23</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31db55XOa505a3f19f25843c4b31db5400">
              <SHORT-NAME>RFSDA_BKPCANFD_100ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31db55xOa505a3f19f25843c4b31db6e00">
                  <SHORT-NAME>RFSDA_100ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_100ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d67aXOa505a3f19f25843c4b31d67900">
              <SHORT-NAME>RFSDA_BKPCANFD_20ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d67axOa505a3f19f25843c4b31d69700">
                  <SHORT-NAME>RFSDA_20ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RFSDA_20ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eddaXOa505a3f19f25843c4b35edd900">
              <SHORT-NAME>RFSDA_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eddaxOa505a3f19f25843c4b35edf400">
                  <SHORT-NAME>NmPDU_BKPCANFD_RFSDA</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32739dXOa505a3f19f25843c4b32739c00">
              <SHORT-NAME>RHRDA_BKPCANFD_50ms_FrP04</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32739dxOa505a3f19f25843c4b3273b600">
                  <SHORT-NAME>RHRDA_50ms_PDU04</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHRDA_50ms_PDU04</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ee05XOa505a3f19f25843c4b35ee0400">
              <SHORT-NAME>RHRDA_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ee05xOa505a3f19f25843c4b35ee1f00">
                  <SHORT-NAME>NmPDU_BKPCANFD_RHRDA</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31de55XOa505a3f19f25843c4b31de5400">
              <SHORT-NAME>RHZCU_BDCAN_100ms_FrP06</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31de55xOa505a3f19f25843c4b31de6e00">
                  <SHORT-NAME>RHZCU_100ms_PDU06</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU06</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b585XOa505a3f19f25843c4b33b58400">
              <SHORT-NAME>RHZCU_BKBCANFD_50ms_FrP27</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b585xOa505a3f19f25843c4b33b59e00">
                  <SHORT-NAME>RHZCU_50ms_PDU27</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU27</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f70aaXOa505a3f19f25843c4b2f70a900">
              <SHORT-NAME>RHZCU_ICBVC_LHBKBCANFD_50ms_FrP14</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f70aaxOa505a3f19f25843c4b2f70c400">
                  <SHORT-NAME>RHZCU_ICBVC_50ms_PDU14</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_ICBVC_50ms_PDU14</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3021feXOa505a3f19f25843c4b3021fd00">
              <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP10</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3021fexOa505a3f19f25843c4b30221800">
                  <SHORT-NAME>RHZCU_100ms_PDU10</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU10</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b302281XOa505a3f19f25843c4b30228000">
              <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP15</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b302281xOa505a3f19f25843c4b30229a00">
                  <SHORT-NAME>RHZCU_100ms_PDU15</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU15</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f715bXOa505a3f19f25843c4b2f715a00">
              <SHORT-NAME>RHZCU_RHBKBCANFD_100ms_FrP20</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f715bxOa505a3f19f25843c4b2f717400">
                  <SHORT-NAME>RHZCU_100ms_PDU20</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_100ms_PDU20</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33b5afXOa505a3f19f25843c4b33b5ae00">
              <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33b5afxOa505a3f19f25843c4b33b5c800">
                  <SHORT-NAME>RHZCU_50ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f71e1XOa505a3f19f25843c4b2f71e000">
              <SHORT-NAME>RHZCU_RHBKBCANFD_50ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f71e1xOa505a3f19f25843c4b2f71fa00">
                  <SHORT-NAME>RHZCU_50ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RHZCU_50ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eab0XOa505a3f19f25843c4b35eaaf00">
              <SHORT-NAME>RZCU_CHCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eab0xOa505a3f19f25843c4b35eaca00">
                  <SHORT-NAME>NmPDU_CHCANFD_RZCU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33467eXOa505a3f19f25843c4b33467d00">
              <SHORT-NAME>RZCU_ERCANFD_100ms_FrP49</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33467exOa505a3f19f25843c4b33469b00">
                  <SHORT-NAME>RZCU_100ms_PDU49</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU49</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b334650XOa505a3f19f25843c4b33464f00">
              <SHORT-NAME>RZCU_ERCANFD_10ms_FrP41</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b334650xOa505a3f19f25843c4b33466d00">
                  <SHORT-NAME>RZCU_10ms_PDU41</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU41</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f37b7XOa505a3f19f25843c4b2f37b600">
              <SHORT-NAME>RZCU_LHBKBCANFD_50ms_FrP37</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f37b7xOa505a3f19f25843c4b2f37d000">
                  <SHORT-NAME>RZCU_50ms_PDU37</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU37</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3022abXOa505a3f19f25843c4b3022aa00">
              <SHORT-NAME>RZCU_PTCANFD_100ms_FrP10</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3022abxOa505a3f19f25843c4b3022c400">
                  <SHORT-NAME>RZCU_100ms_PDU10</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_100ms_PDU10</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b357532XOa505a3f19f25843c4b35753100">
              <SHORT-NAME>RZCU_PTCANFD_10ms_FrP90</SHORT-NAME>
              <FRAME-LENGTH>20</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b357532xOa505a3f19f25843c4b35755100">
                  <SHORT-NAME>RZCU_10ms_PDU90</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU90</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b302383XOa505a3f19f25843c4b30238200">
              <SHORT-NAME>RZCU_PTCANFD_20ms_ConFrP06</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b302383xOa505a3f19f25843c4b3023a000">
                  <SHORT-NAME>IMCU_PTCANFD_20ms_Container01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IMCU_PTCANFD_20ms_Container01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ec4bXOa505a3f19f25843c4b35ec4a00">
              <SHORT-NAME>RZCU_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ec4bxOa505a3f19f25843c4b35ec6500">
                  <SHORT-NAME>NmPDU_PTCANFD_RZCU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326195XOa505a3f19f25843c4b32619400">
              <SHORT-NAME>RZCU_RZCUCANFD_1000ms_FrP67</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326195xOa505a3f19f25843c4b3261b200">
                  <SHORT-NAME>RZCU_1000ms_PDU67</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_1000ms_PDU67</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3344c9XOa505a3f19f25843c4b3344c800">
              <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP22_NoSecOC</SHORT-NAME>
              <FRAME-LENGTH>12</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3344c9xOa505a3f19f25843c4b3344e600">
                  <SHORT-NAME>RZCU_10ms_PDU22</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU22</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N200000119f5e170b8e1fa09XN200000119f5e170b8e1fa0300">
              <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP23</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N200000119f5e170b8e1fa09xN20000011a02779c9f443e3600">
                  <SHORT-NAME>RZCU_10ms_PDU23</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU23</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b302467XOa505a3f19f25843c4b30246600">
              <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP24</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b302467xOa505a3f19f25843c4b30248000">
                  <SHORT-NAME>RZCU_10ms_PDU24</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU24</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b334471XOa505a3f19f25843c4b33447000">
              <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP64</SHORT-NAME>
              <FRAME-LENGTH>32</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b334471xOa505a3f19f25843c4b33448e00">
                  <SHORT-NAME>RZCU_10ms_PDU64</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_10ms_PDU64</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b328261XOa505a3f19f25843c4b32826000">
              <SHORT-NAME>RZCU_RZCUCANFD_50ms_FrP25</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b328261xOa505a3f19f25843c4b32827a00">
                  <SHORT-NAME>RZCU_50ms_PDU25</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/RZCU_50ms_PDU25</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b302355XOa505a3f19f25843c4b30235400">
              <SHORT-NAME>RZCU_SFCANFD_10ms_ConFrP08</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b302355xOa505a3f19f25843c4b30237200">
                  <SHORT-NAME>IMCU_SFCANFD_10ms_Container08</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="CONTAINER-I-PDU">/Communication/PDUs/IMCU_SFCANFD_10ms_Container08</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f1deXOa505a3f19f25843c4b35f1dd00">
              <SHORT-NAME>RZCU_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f1dexOa505a3f19f25843c4b35f1f800">
                  <SHORT-NAME>NmPDU_SFCANFD_RZCU</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ec76XOa505a3f19f25843c4b35ec7500">
              <SHORT-NAME>SAC_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ec76xOa505a3f19f25843c4b35ec9000">
                  <SHORT-NAME>NmPDU_PTCANFD_SAC</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f1ebaXOa505a3f19f25843c4b2f1eb900">
              <SHORT-NAME>SDM_CHCANFD_100ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f1ebaxOa505a3f19f25843c4b2f1ed300">
                  <SHORT-NAME>SDM_100ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_100ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f1e3dXOa505a3f19f25843c4b2f1e3c00">
              <SHORT-NAME>SDM_CHCANFD_20ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f1e3dxOa505a3f19f25843c4b2f1e5800">
                  <SHORT-NAME>SDM_20ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f1e90XOa505a3f19f25843c4b2f1e8f00">
              <SHORT-NAME>SDM_CHCANFD_20ms_FrP02</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f1e90xOa505a3f19f25843c4b2f1ea900">
                  <SHORT-NAME>SDM_20ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b2f1f0fXOa505a3f19f25843c4b2f1f0e00">
              <SHORT-NAME>SDM_CHCANFD_20ms_FrP03</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b2f1f0fxOa505a3f19f25843c4b2f1f2800">
                  <SHORT-NAME>SDM_20ms_PDU03</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/SDM_20ms_PDU03</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f209XOa505a3f19f25843c4b35f20800">
              <SHORT-NAME>SDM_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f209xOa505a3f19f25843c4b35f22300">
                  <SHORT-NAME>NmPDU_SFCANFD_SDM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3427b1XOa505a3f19f25843c4b3427b000">
              <SHORT-NAME>TCM_PTCAN_FrP02</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3427b1xOa505a3f19f25843c4b3427ca00">
                  <SHORT-NAME>TCM_025ms_PDU02</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU02</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N200000119f4464397e360fcXN200000119f4464397e360f600">
              <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N200000119f4464397e360fcxN200000119f4464397e3611500">
                  <SHORT-NAME>TCM_025ms_PDU05</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU05</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b34ce09XOa505a3f19f25843c4b34ce0800">
              <SHORT-NAME>TCM_PTEXTCAN2_FrP18</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b34ce09xOa505a3f19f25843c4b34ce2200">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_020ms_PDU18</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N200000119f4464397e3608cXN200000119f4464397e3608600">
              <SHORT-NAME>TCM_PTEXTCAN2_FrP20</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N200000119f4464397e3608cxN200000119f4464397e360a600">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TCM_025ms_PDU20</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b33414fXOa505a3f19f25843c4b33414e00">
              <SHORT-NAME>TC_IMCU_ERCANFD_50ms_FrP28</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b33414fxOa505a3f19f25843c4b33416800">
                  <SHORT-NAME>TC_IMCU_50ms_PDU28</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TC_IMCU_50ms_PDU28</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31d95bXOa505a3f19f25843c4b31d95a00">
              <SHORT-NAME>TDM_SFCANFD_200ms_FrP01</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31d95bxOa505a3f19f25843c4b31d97800">
                  <SHORT-NAME>TDM_200ms_PDU01</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TDM_200ms_PDU01</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35f25fXOa505a3f19f25843c4b35f25e00">
              <SHORT-NAME>TDM_SFCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35f25fxOa505a3f19f25843c4b35f27900">
                  <SHORT-NAME>NmPDU_SFCANFD_TDM</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b31e22fXOa505a3f19f25843c4b31e22e00">
              <SHORT-NAME>TPMS_LHBDEXTDCAN_400ms_FrP06</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b31e22fxOa505a3f19f25843c4b31e24800">
                  <SHORT-NAME>TPMS_400ms_PDU06</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/TPMS_400ms_PDU06</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32783fXOa505a3f19f25843c4b32783e00">
              <SHORT-NAME>Tester_ECM_SFCANFD_10ms_FrP20</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32783fxOa505a3f19f25843c4b32785800">
                  <SHORT-NAME>Teter_ECM_10ms_PDU20</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/Teter_ECM_10ms_PDU20</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b326d85XOa505a3f19f25843c4b326d8400">
              <SHORT-NAME>ZXD_BKBCANFD_100ms_FrP257</SHORT-NAME>
              <FRAME-LENGTH>24</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b326d85xOa505a3f19f25843c4b326da200">
                  <SHORT-NAME>ICBVC_100ms_PDU257</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_100ms_PDU257</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b32764eXOa505a3f19f25843c4b32764d00">
              <SHORT-NAME>ZXD_BKBCANFD_50ms_FrP256</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b32764exOa505a3f19f25843c4b32766c00">
                  <SHORT-NAME>ICBVC_50ms_PDU256</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ICBVC_50ms_PDU256</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b3285a4XOa505a3f19f25843c4b3285a300">
              <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP76</SHORT-NAME>
              <FRAME-LENGTH>16</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b3285a4xOa505a3f19f25843c4b3285c100">
                  <SHORT-NAME>ZXD_100ms_PDU76</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU76</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N200000119f4464397e2fa30XN200000119f4464397e2fa2a00">
              <SHORT-NAME>ZXD_BKPCANFD_100ms_FrP77</SHORT-NAME>
              <FRAME-LENGTH>64</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N200000119f4464397e2fa30xN200000119f4464397e2fa4c00">
                  <SHORT-NAME>ZXD_100ms_PDU77</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="I-SIGNAL-I-PDU">/Communication/PDUs/ZXD_100ms_PDU77</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ed02XOa505a3f19f25843c4b35ed0100">
              <SHORT-NAME>ZXD_BKPCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ed02xOa505a3f19f25843c4b35ed1d00">
                  <SHORT-NAME>NmPDU_BKPCANFD_ZXD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35ea5aXOa505a3f19f25843c4b35ea5900">
              <SHORT-NAME>ZXD_CHCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35ea5axOa505a3f19f25843c4b35ea7400">
                  <SHORT-NAME>NmPDU_CHCANFD_ZXD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="Oa505a3f19f25843c4b35eb9fXOa505a3f19f25843c4b35eb9e00">
              <SHORT-NAME>ZXD_PTCANFD_NM</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="Oa505a3f19f25843c4b35eb9fxOa505a3f19f25843c4b35ebb900">
                  <SHORT-NAME>NmPDU_PTCANFD_ZXD</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
            <CAN-FRAME UUID="N20000011a036646ff92481dXN20000011a036646ff92481c00">
              <SHORT-NAME>synthesized_ICBVC_SecOC_SyncMsg_BKPCANFD</SHORT-NAME>
              <FRAME-LENGTH>8</FRAME-LENGTH>
              <PDU-TO-FRAME-MAPPINGS>
                <PDU-TO-FRAME-MAPPING UUID="N20000011a036646ff92481dxN20000011a036646ff92481e00">
                  <SHORT-NAME>synthesized_ICBVC_SecOC_SyncMsg</SHORT-NAME>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-LAST</PACKING-BYTE-ORDER>
                  <PDU-REF DEST="SECURED-I-PDU">/Communication/PDUs/SecuredIPdu_ICC_SecOC_SyncMsg_BKPCANFD</PDU-REF>
                  <START-POSITION>0</START-POSITION>
                </PDU-TO-FRAME-MAPPING>
              </PDU-TO-FRAME-MAPPINGS>
            </CAN-FRAME>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="ac9c2182f0ea34948faecdee8a2654fa">
          <SHORT-NAME>NetworkManagement</SHORT-NAME>
          <ELEMENTS>
            <NM-CONFIG UUID="Oa505a3f19f25843c4b3e1addXOa505a3f19f25843c4b3e1adc00">
              <SHORT-NAME>BKPCANFDNmConfig</SHORT-NAME>
              <NM-CLUSTERS>
                <CAN-NM-CLUSTER UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1c2000">
                  <SHORT-NAME>BKPCANFD_Cluster</SHORT-NAME>
                  <COMMUNICATION-CLUSTER-REF DEST="CAN-CLUSTER">/Topology/Clusters/BKPCANFD</COMMUNICATION-CLUSTER-REF>
                  <NM-CHANNEL-ID>8</NM-CHANNEL-ID>
                  <NM-NODES>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1c9400">
                      <SHORT-NAME>FDR_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>230</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1cdf00">
                      <SHORT-NAME>IMM_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>213</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1c8500">
                      <SHORT-NAME>IPD_BKPCANFD</SHORT-NAME>
                      <CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_BKPCANFD1</CONTROLLER-REF>
                      <NM-IF-ECU-REF DEST="NM-ECU">/Communication/NetworkManagement/BKPCANFDNmConfig/IPD</NM-IF-ECU-REF>
                      <NM-NODE-ID>178</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1ca300">
                      <SHORT-NAME>LFSDA_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>207</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1cb200">
                      <SHORT-NAME>LHRDA_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>205</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1cc100">
                      <SHORT-NAME>RFSDA_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>206</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1cd000">
                      <SHORT-NAME>RHRDA_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>204</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1c7500">
                      <SHORT-NAME>ZXD_BKPCANFD</SHORT-NAME>
                      <NM-NODE-ID>192</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_FDR</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IMM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_LHRDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RFSDA</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_RHRDA</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_BKPCANFD_ZXD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                  </NM-NODES>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-REPEAT-MSG-IND-ENABLED>true</NM-REPEAT-MSG-IND-ENABLED>
                  <NM-CBV-POSITION>1</NM-CBV-POSITION>
                  <NM-IMMEDIATE-NM-CYCLE-TIME>0.01</NM-IMMEDIATE-NM-CYCLE-TIME>
                  <NM-IMMEDIATE-NM-TRANSMISSIONS>20</NM-IMMEDIATE-NM-TRANSMISSIONS>
                  <NM-MESSAGE-TIMEOUT-TIME>0.08</NM-MESSAGE-TIMEOUT-TIME>
                  <NM-MSG-CYCLE-TIME>0.1</NM-MSG-CYCLE-TIME>
                  <NM-NETWORK-TIMEOUT>5</NM-NETWORK-TIMEOUT>
                  <NM-NID-POSITION>0</NM-NID-POSITION>
                  <NM-REMOTE-SLEEP-INDICATION-TIME>2</NM-REMOTE-SLEEP-INDICATION-TIME>
                  <NM-REPEAT-MESSAGE-TIME>1</NM-REPEAT-MESSAGE-TIME>
                  <NM-USER-DATA-LENGTH>6</NM-USER-DATA-LENGTH>
                  <NM-WAIT-BUS-SLEEP-TIME>1</NM-WAIT-BUS-SLEEP-TIME>
                </CAN-NM-CLUSTER>
              </NM-CLUSTERS>
              <NM-IF-ECUS>
                <NM-ECU UUID="Oa505a3f19f25843c4b3e1addxOa505a3f19f25843c4b3e1b0f00">
                  <SHORT-NAME>IPD</SHORT-NAME>
                  <BUS-SPECIFIC-NM-ECU>
                    <CAN-NM-ECU />
                  </BUS-SPECIFIC-NM-ECU>
                  <ECU-INSTANCE-REF DEST="ECU-INSTANCE">/Topology/HardwareComponents/IPD</ECU-INSTANCE-REF>
                  <NM-COM-CONTROL-ENABLED>true</NM-COM-CONTROL-ENABLED>
                  <NM-CYCLETIME-MAIN-FUNCTION>0.01</NM-CYCLETIME-MAIN-FUNCTION>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-PASSIVE-MODE-ENABLED>false</NM-PASSIVE-MODE-ENABLED>
                  <NM-PDU-RX-INDICATION-ENABLED>true</NM-PDU-RX-INDICATION-ENABLED>
                  <NM-STATE-CHANGE-IND-ENABLED>true</NM-STATE-CHANGE-IND-ENABLED>
                  <NM-USER-DATA-ENABLED>true</NM-USER-DATA-ENABLED>
                </NM-ECU>
              </NM-IF-ECUS>
            </NM-CONFIG>
            <NM-CONFIG UUID="Oa505a3f19f25843c4b3e15ebXOa505a3f19f25843c4b3e15ea00">
              <SHORT-NAME>CHCANFDNmConfig</SHORT-NAME>
              <NM-CLUSTERS>
                <CAN-NM-CLUSTER UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e16b900">
                  <SHORT-NAME>CHCANFD_Cluster</SHORT-NAME>
                  <COMMUNICATION-CLUSTER-REF DEST="CAN-CLUSTER">/Topology/Clusters/CHCANFD</COMMUNICATION-CLUSTER-REF>
                  <NM-CHANNEL-ID>2</NM-CHANNEL-ID>
                  <NM-NODES>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e170e00">
                      <SHORT-NAME>EPS_CHCANFD</SHORT-NAME>
                      <NM-NODE-ID>228</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e171e00">
                      <SHORT-NAME>IBS_CHCANFD</SHORT-NAME>
                      <NM-NODE-ID>248</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e173c00">
                      <SHORT-NAME>IPD_CHCANFD</SHORT-NAME>
                      <CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_CHCANFD1</CONTROLLER-REF>
                      <NM-IF-ECU-REF DEST="NM-ECU">/Communication/NetworkManagement/CHCANFDNmConfig/IPD</NM-IF-ECU-REF>
                      <NM-NODE-ID>178</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e174b00">
                      <SHORT-NAME>RZCU_CHCANFD</SHORT-NAME>
                      <NM-NODE-ID>243</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e172d00">
                      <SHORT-NAME>ZXD_CHCANFD</SHORT-NAME>
                      <NM-NODE-ID>192</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_EPS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_RZCU</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_CHCANFD_ZXD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                  </NM-NODES>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-REPEAT-MSG-IND-ENABLED>true</NM-REPEAT-MSG-IND-ENABLED>
                  <NM-CBV-POSITION>1</NM-CBV-POSITION>
                  <NM-IMMEDIATE-NM-CYCLE-TIME>0.01</NM-IMMEDIATE-NM-CYCLE-TIME>
                  <NM-IMMEDIATE-NM-TRANSMISSIONS>20</NM-IMMEDIATE-NM-TRANSMISSIONS>
                  <NM-MESSAGE-TIMEOUT-TIME>0.08</NM-MESSAGE-TIMEOUT-TIME>
                  <NM-MSG-CYCLE-TIME>0.1</NM-MSG-CYCLE-TIME>
                  <NM-NETWORK-TIMEOUT>5</NM-NETWORK-TIMEOUT>
                  <NM-NID-POSITION>0</NM-NID-POSITION>
                  <NM-REMOTE-SLEEP-INDICATION-TIME>2</NM-REMOTE-SLEEP-INDICATION-TIME>
                  <NM-REPEAT-MESSAGE-TIME>1</NM-REPEAT-MESSAGE-TIME>
                  <NM-USER-DATA-LENGTH>6</NM-USER-DATA-LENGTH>
                  <NM-WAIT-BUS-SLEEP-TIME>1</NM-WAIT-BUS-SLEEP-TIME>
                </CAN-NM-CLUSTER>
              </NM-CLUSTERS>
              <NM-IF-ECUS>
                <NM-ECU UUID="Oa505a3f19f25843c4b3e15ebxOa505a3f19f25843c4b3e166b00">
                  <SHORT-NAME>IPD</SHORT-NAME>
                  <BUS-SPECIFIC-NM-ECU>
                    <CAN-NM-ECU />
                  </BUS-SPECIFIC-NM-ECU>
                  <ECU-INSTANCE-REF DEST="ECU-INSTANCE">/Topology/HardwareComponents/IPD</ECU-INSTANCE-REF>
                  <NM-COM-CONTROL-ENABLED>true</NM-COM-CONTROL-ENABLED>
                  <NM-CYCLETIME-MAIN-FUNCTION>0.01</NM-CYCLETIME-MAIN-FUNCTION>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-PASSIVE-MODE-ENABLED>false</NM-PASSIVE-MODE-ENABLED>
                  <NM-PDU-RX-INDICATION-ENABLED>true</NM-PDU-RX-INDICATION-ENABLED>
                  <NM-STATE-CHANGE-IND-ENABLED>true</NM-STATE-CHANGE-IND-ENABLED>
                  <NM-USER-DATA-ENABLED>true</NM-USER-DATA-ENABLED>
                </NM-ECU>
              </NM-IF-ECUS>
            </NM-CONFIG>
            <NM-CONFIG UUID="Oa505a3f19f25843c4b3e1829XOa505a3f19f25843c4b3e182800">
              <SHORT-NAME>PTCANFDNmConfig</SHORT-NAME>
              <NM-CLUSTERS>
                <CAN-NM-CLUSTER UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e19e100">
                  <SHORT-NAME>PTCANFD_Cluster</SHORT-NAME>
                  <COMMUNICATION-CLUSTER-REF DEST="CAN-CLUSTER">/Topology/Clusters/PTCANFD</COMMUNICATION-CLUSTER-REF>
                  <NM-CHANNEL-ID>1</NM-CHANNEL-ID>
                  <NM-NODES>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a4600">
                      <SHORT-NAME>CCU_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>224</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a3600">
                      <SHORT-NAME>ESS_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>225</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a8200">
                      <SHORT-NAME>IPD_PTCANFD</SHORT-NAME>
                      <CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_PTCANFD1</CONTROLLER-REF>
                      <NM-IF-ECU-REF DEST="NM-ECU">/Communication/NetworkManagement/PTCANFDNmConfig/IPD</NM-IF-ECU-REF>
                      <NM-NODE-ID>178</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1acd00">
                      <SHORT-NAME>LVBM_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>144</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a9100">
                      <SHORT-NAME>MMCU_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>242</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a5500">
                      <SHORT-NAME>PEU_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>146</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1abe00">
                      <SHORT-NAME>PEU_PTCANFD1</SHORT-NAME>
                      <NM-NODE-ID>146</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a6400">
                      <SHORT-NAME>PICM_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>172</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1aa000">
                      <SHORT-NAME>RZCU_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>243</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1aaf00">
                      <SHORT-NAME>SAC_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>241</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e1a7300">
                      <SHORT-NAME>ZXD_PTCANFD</SHORT-NAME>
                      <NM-NODE-ID>192</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_CCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ESS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_LVBM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_MMCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_SAC</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_PTCANFD_ZXD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                  </NM-NODES>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-REPEAT-MSG-IND-ENABLED>true</NM-REPEAT-MSG-IND-ENABLED>
                  <NM-CBV-POSITION>1</NM-CBV-POSITION>
                  <NM-IMMEDIATE-NM-CYCLE-TIME>0.01</NM-IMMEDIATE-NM-CYCLE-TIME>
                  <NM-IMMEDIATE-NM-TRANSMISSIONS>20</NM-IMMEDIATE-NM-TRANSMISSIONS>
                  <NM-MESSAGE-TIMEOUT-TIME>0.08</NM-MESSAGE-TIMEOUT-TIME>
                  <NM-MSG-CYCLE-TIME>0.1</NM-MSG-CYCLE-TIME>
                  <NM-NETWORK-TIMEOUT>5</NM-NETWORK-TIMEOUT>
                  <NM-NID-POSITION>0</NM-NID-POSITION>
                  <NM-REMOTE-SLEEP-INDICATION-TIME>2</NM-REMOTE-SLEEP-INDICATION-TIME>
                  <NM-REPEAT-MESSAGE-TIME>1</NM-REPEAT-MESSAGE-TIME>
                  <NM-USER-DATA-LENGTH>6</NM-USER-DATA-LENGTH>
                  <NM-WAIT-BUS-SLEEP-TIME>1</NM-WAIT-BUS-SLEEP-TIME>
                </CAN-NM-CLUSTER>
              </NM-CLUSTERS>
              <NM-IF-ECUS>
                <NM-ECU UUID="Oa505a3f19f25843c4b3e1829xOa505a3f19f25843c4b3e18f700">
                  <SHORT-NAME>IPD</SHORT-NAME>
                  <BUS-SPECIFIC-NM-ECU>
                    <CAN-NM-ECU />
                  </BUS-SPECIFIC-NM-ECU>
                  <ECU-INSTANCE-REF DEST="ECU-INSTANCE">/Topology/HardwareComponents/IPD</ECU-INSTANCE-REF>
                  <NM-COM-CONTROL-ENABLED>true</NM-COM-CONTROL-ENABLED>
                  <NM-CYCLETIME-MAIN-FUNCTION>0.01</NM-CYCLETIME-MAIN-FUNCTION>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-PASSIVE-MODE-ENABLED>false</NM-PASSIVE-MODE-ENABLED>
                  <NM-PDU-RX-INDICATION-ENABLED>true</NM-PDU-RX-INDICATION-ENABLED>
                  <NM-STATE-CHANGE-IND-ENABLED>true</NM-STATE-CHANGE-IND-ENABLED>
                  <NM-USER-DATA-ENABLED>true</NM-USER-DATA-ENABLED>
                </NM-ECU>
              </NM-IF-ECUS>
            </NM-CONFIG>
            <NM-CONFIG UUID="Oa505a3f19f25843c4b3e21e1XOa505a3f19f25843c4b3e21e000">
              <SHORT-NAME>SFCANFDNmConfig</SHORT-NAME>
              <NM-CLUSTERS>
                <CAN-NM-CLUSTER UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e22fd00">
                  <SHORT-NAME>SFCANFD_Cluster</SHORT-NAME>
                  <COMMUNICATION-CLUSTER-REF DEST="CAN-CLUSTER">/Topology/Clusters/SFCANFD</COMMUNICATION-CLUSTER-REF>
                  <NM-CHANNEL-ID>7</NM-CHANNEL-ID>
                  <NM-NODES>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e235200">
                      <SHORT-NAME>IBS_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>248</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e236200">
                      <SHORT-NAME>IPD_SFCANFD</SHORT-NAME>
                      <CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_SFCANFD1</CONTROLLER-REF>
                      <NM-IF-ECU-REF DEST="NM-ECU">/Communication/NetworkManagement/SFCANFDNmConfig/IPD</NM-IF-ECU-REF>
                      <NM-NODE-ID>178</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e239e00">
                      <SHORT-NAME>PEU_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>146</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e237100">
                      <SHORT-NAME>PICM_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>172</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e238000">
                      <SHORT-NAME>RZCU_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>243</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e238f00">
                      <SHORT-NAME>SDM_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>227</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                    <CAN-NM-NODE UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e23ad00">
                      <SHORT-NAME>TDM_SFCANFD</SHORT-NAME>
                      <NM-NODE-ID>247</NM-NODE-ID>
                      <RX-NM-PDU-REFS>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IBS</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_IPD</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PEU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_PICM</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_RZCU</RX-NM-PDU-REF>
                        <RX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_SDM</RX-NM-PDU-REF>
                      </RX-NM-PDU-REFS>
                      <TX-NM-PDU-REFS>
                        <TX-NM-PDU-REF DEST="NM-PDU">/Communication/PDUs/NmPDU_SFCANFD_TDM</TX-NM-PDU-REF>
                      </TX-NM-PDU-REFS>
                      <NM-CAR-WAKE-UP-FILTER-ENABLED>false</NM-CAR-WAKE-UP-FILTER-ENABLED>
                      <NM-CAR-WAKE-UP-RX-ENABLED>false</NM-CAR-WAKE-UP-RX-ENABLED>
                    </CAN-NM-NODE>
                  </NM-NODES>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-REPEAT-MSG-IND-ENABLED>true</NM-REPEAT-MSG-IND-ENABLED>
                  <NM-CBV-POSITION>1</NM-CBV-POSITION>
                  <NM-IMMEDIATE-NM-CYCLE-TIME>0.01</NM-IMMEDIATE-NM-CYCLE-TIME>
                  <NM-IMMEDIATE-NM-TRANSMISSIONS>20</NM-IMMEDIATE-NM-TRANSMISSIONS>
                  <NM-MESSAGE-TIMEOUT-TIME>0.08</NM-MESSAGE-TIMEOUT-TIME>
                  <NM-MSG-CYCLE-TIME>0.1</NM-MSG-CYCLE-TIME>
                  <NM-NETWORK-TIMEOUT>5</NM-NETWORK-TIMEOUT>
                  <NM-NID-POSITION>0</NM-NID-POSITION>
                  <NM-REMOTE-SLEEP-INDICATION-TIME>2</NM-REMOTE-SLEEP-INDICATION-TIME>
                  <NM-REPEAT-MESSAGE-TIME>1</NM-REPEAT-MESSAGE-TIME>
                  <NM-USER-DATA-LENGTH>6</NM-USER-DATA-LENGTH>
                  <NM-WAIT-BUS-SLEEP-TIME>1</NM-WAIT-BUS-SLEEP-TIME>
                </CAN-NM-CLUSTER>
              </NM-CLUSTERS>
              <NM-IF-ECUS>
                <NM-ECU UUID="Oa505a3f19f25843c4b3e21e1xOa505a3f19f25843c4b3e221300">
                  <SHORT-NAME>IPD</SHORT-NAME>
                  <BUS-SPECIFIC-NM-ECU>
                    <CAN-NM-ECU />
                  </BUS-SPECIFIC-NM-ECU>
                  <ECU-INSTANCE-REF DEST="ECU-INSTANCE">/Topology/HardwareComponents/IPD</ECU-INSTANCE-REF>
                  <NM-COM-CONTROL-ENABLED>true</NM-COM-CONTROL-ENABLED>
                  <NM-CYCLETIME-MAIN-FUNCTION>0.01</NM-CYCLETIME-MAIN-FUNCTION>
                  <NM-NODE-DETECTION-ENABLED>true</NM-NODE-DETECTION-ENABLED>
                  <NM-NODE-ID-ENABLED>true</NM-NODE-ID-ENABLED>
                  <NM-PASSIVE-MODE-ENABLED>false</NM-PASSIVE-MODE-ENABLED>
                  <NM-PDU-RX-INDICATION-ENABLED>true</NM-PDU-RX-INDICATION-ENABLED>
                  <NM-STATE-CHANGE-IND-ENABLED>true</NM-STATE-CHANGE-IND-ENABLED>
                  <NM-USER-DATA-ENABLED>true</NM-USER-DATA-ENABLED>
                </NM-ECU>
              </NM-IF-ECUS>
            </NM-CONFIG>
          </ELEMENTS>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="41920188a29b3979b984931eaa43f262">
          <SHORT-NAME>PDUs</SHORT-NAME>
          <ELEMENTS>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358f88XOa505a3f19f25843c4b358f8700">
              <SHORT-NAME>BMS_ZONE_PTCANFD_100ms_Container02</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.1</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_PDU19</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_PDU25</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_PDU28</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_PDU54</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ESS_100ms_PDU58</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.1</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358fd0XOa505a3f19f25843c4b358fcf00">
              <SHORT-NAME>ECM_ERCANFD_100ms_container10</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.1</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_100ms_PDU10</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_100ms_PDU11</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/ECM_100ms_PDU12</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.1</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358efcXOa505a3f19f25843c4b358efb00">
              <SHORT-NAME>EPS_ZONE_CHCANFD_10ms_Container01</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.01</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_010ms_PDU03</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_10ms_PDU01</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_10ms_PDU02</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.01</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358e46XOa505a3f19f25843c4b358e4500">
              <SHORT-NAME>IBS_CHCANFD_10ms_Container01</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.01</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_10ms_PDU04</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.01</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358e21XOa505a3f19f25843c4b358e2000">
              <SHORT-NAME>IBS_CHCANFD_20ms_Container01</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.02</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU10</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/IBS_20ms_PDU13</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.02</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b359018XOa505a3f19f25843c4b35901700">
              <SHORT-NAME>IMCU_PTCANFD_20ms_Container01</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.02</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_PDU06</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_20ms_PDU07</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RZCU_20ms_PDU06</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.02</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358ff4XOa505a3f19f25843c4b358ff300">
              <SHORT-NAME>IMCU_SFCANFD_10ms_Container08</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <TIMEOUT>0.01</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_PDU01</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/PTCANFD/PTCANFD/RZCU_10ms_PDU02</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RZCU_10ms_PDU01</CONTAINED-PDU-TRIGGERING-REF>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/SFCANFD/SFCANFD/RZCU_10ms_PDU02</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.01</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <CONTAINER-I-PDU UUID="Oa505a3f19f25843c4b358f20XOa505a3f19f25843c4b358f1f00">
              <SHORT-NAME>SAS_ZONE_CHCANFD_10ms_Container01</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <CONTAINED-PDU-TRIGGERING-REFS>
                <CONTAINED-PDU-TRIGGERING-REF DEST="PDU-TRIGGERING">/Topology/Clusters/CHCANFD/CHCANFD/EPS_10ms_PDU05</CONTAINED-PDU-TRIGGERING-REF>
              </CONTAINED-PDU-TRIGGERING-REFS>
              <CONTAINER-TIMEOUT>0.01</CONTAINER-TIMEOUT>
              <CONTAINER-TRIGGER>DEFAULT-TRIGGER</CONTAINER-TRIGGER>
              <HEADER-TYPE>SHORT-HEADER</HEADER-TYPE>
              <RX-ACCEPT-CONTAINED-I-PDU>ACCEPT-CONFIGURED</RX-ACCEPT-CONTAINED-I-PDU>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </CONTAINER-I-PDU>
            <DCM-I-PDU UUID="Oa505a3f19f25843c4b35f827XOa505a3f19f25843c4b35f82600">
              <SHORT-NAME>DIAG_BKPCANFD_FuncReq_SDU</SHORT-NAME>
              <LENGTH>7</LENGTH>
              <DIAG-PDU-TYPE>DIAG-REQUEST</DIAG-PDU-TYPE>
            </DCM-I-PDU>
            <DCM-I-PDU UUID="Oa505a3f19f25843c4b35f86dXOa505a3f19f25843c4b35f86c00">
              <SHORT-NAME>DIAG_BKPCANFD_PhyReq_IPD_SDU</SHORT-NAME>
              <LENGTH>4095</LENGTH>
              <DIAG-PDU-TYPE>DIAG-REQUEST</DIAG-PDU-TYPE>
            </DCM-I-PDU>
            <DCM-I-PDU UUID="Oa505a3f19f25843c4b35f884XOa505a3f19f25843c4b35f88300">
              <SHORT-NAME>DIAG_BKPCANFD_PhyResp_IPD_SDU</SHORT-NAME>
              <LENGTH>4095</LENGTH>
              <DIAG-PDU-TYPE>DIAG-RESPONSE</DIAG-PDU-TYPE>
            </DCM-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b321000XOa505a3f19f25843c4b320fff00">
              <SHORT-NAME>BCM_100ms_PDU41</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/BCM_100ms_PDU41/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/BCM_100ms_PDU41/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b321000xOa505a3f19f25843c4b32102b00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrTireStdPrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b321000xOa505a3f19f25843c4b32100f00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtTireStdPrs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>0</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f0cb1XOa505a3f19f25843c4b2f0cb000">
              <SHORT-NAME>CCU_100ms_PDU02</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU02/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d0e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d2900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d5f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0cf300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d4400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0de600">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d7a00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0dcb00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0db000">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDUHVILSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0d9500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrHVILStsValV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0cc300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCHVILSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0e0100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0e1c00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0e3700">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group02_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f0cb1xOa505a3f19f25843c4b2f0cdf00">
                  <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group02</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f1326XOa505a3f19f25843c4b2f132500">
              <SHORT-NAME>CCU_100ms_PDU04</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU04/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f133900">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCCurrentMaxHV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f147d00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IInerDschrgTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f135400">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCOverCurrentHV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f136f00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCOverCurrentLV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f138a00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCOverVoltHV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f13a500">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCOverVoltLV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f13c000">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCUnderVoltHV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f13db00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCUnderVoltLV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f13f600">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCVoltFail</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f146200">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDschrgOptMaxPwrV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f142c00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUInnrDschrgplugin</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f141100">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUInnrDschrgSpRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd1400">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_AcIptSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd4800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_CCRes</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd6200">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_CPFrq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fcfa00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_ACPwr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>66</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd2e00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_AcIptType</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd9600">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_S2Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>80</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fcde00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_ACInpFrq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2e61b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUInnrDschrgReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>88</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2fd7c00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOBC_CPVolt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2ff8900">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntK1OtsdVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2ffa500">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntK3OtsdVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2e69e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdchgrK2RelaySts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>116</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2e68400">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdchgrK1RelaySts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2e6d200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdchgrK4RelaySts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>124</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xN200000119f4464397e2e6b800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdchgrK3RelaySts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f144700">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDschrgOptMaxPwr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1326xOa505a3f19f25843c4b2f149800">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrOptAltPwr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f1507XOa505a3f19f25843c4b2f150600">
              <SHORT-NAME>CCU_100ms_PDU07</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU07/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e6ec00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e70600">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e65000">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOnV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f2800">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2ffd900">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e300dd00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrWkup</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e300c300">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e300f700">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrAltrCrntInptHVCrntLmt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f9000">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3012b00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3011100">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOpngMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f7600">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2ff5500">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptCrnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2ff6f00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrAltrCrntInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3014500">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptCrntVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35faa00">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>66</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e300a900">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrOtptVolV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3015f00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnbdChrgrOtptVolVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2fff300">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptCrnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3000d00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL1AltrCrntInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3002700">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptCrnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3004100">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL2AltrCrntInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3005b00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptCrnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3007500">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrL3AltrCrntInptVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e5e100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUActiveWkup</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>136</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f0d00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrMaxChrgPwr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35fc400">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>147</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e63600">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrPlugOn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35fde00">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>155</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e66a00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSpRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35ff800">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3602c00">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>169</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3008f00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrLastWkup</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>170</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e3601200">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>175</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f4200">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>176</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2ffbf00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOnBdChrgrCtrlPilotPWMDuty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e35f5c00">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group07_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>191</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f1507xN200000119f4464397e2e5fc00">
                  <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group07</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f192bXOa505a3f19f25843c4b2f192a00">
              <SHORT-NAME>CCU_100ms_PDU11</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/AirCtrlrHVILClsd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/AirCtrlrHVILClsdV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/CCUClntFlowReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/CCUOnbdChrgrSktEleccLckEnable</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/CCU_100ms_Group11_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/CCU_100ms_Group11_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/ESSPTCHVILSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/ESSPTCHVILStsV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/HVDCDCClntPumpPWMReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/HVDCDCHdwrFlr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/HVDCDCIntnlFlr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/CCU_100ms_PDU11/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f198800">
                  <SHORT-NAME>CCU_100ms_Group11_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f19a300">
                  <SHORT-NAME>CCU_100ms_Group11_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a7b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f193e00">
                  <SHORT-NAME>AirCtrlrHVILClsd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a9500">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f19be00">
                  <SHORT-NAME>CCUClntFlowReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUClntFlowReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1aaf00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a2a00">
                  <SHORT-NAME>HVDCDCClntPumpPWMReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCClntPumpPWMReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f196d00">
                  <SHORT-NAME>AirCtrlrHVILClsdV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirCtrlrHVILClsdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f19f400">
                  <SHORT-NAME>ESSPTCHVILSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f19d900">
                  <SHORT-NAME>CCUOnbdChrgrSktEleccLckEnable</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCUOnbdChrgrSktEleccLckEnable</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1ac900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1afd00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a6000">
                  <SHORT-NAME>HVDCDCIntnlFlr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCIntnlFlr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a4500">
                  <SHORT-NAME>HVDCDCHdwrFlr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHVDCDCHdwrFlr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1a0f00">
                  <SHORT-NAME>ESSPTCHVILStsV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSPTCHVILStsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1ae300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b1700">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b3100">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b4b00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b6500">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b7f00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1b9900">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved12</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1bb300">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved13</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f1bcd00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_100ms_Group11_Reserved14</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f192bxOa505a3f19f25843c4b2f195900">
                  <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/ICCU_100ms_Group11</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30e73eXOa505a3f19f25843c4b30e73d00">
              <SHORT-NAME>DIAG_DTCInfo_ICBAD</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/DIAG_DTCInfo_ICBAD/DTCInfomationIPD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30e73exOa505a3f19f25843c4b30e75000">
                  <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDTCInfomationIPD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b329fc1XOa505a3f19f25843c4b329fc000">
              <SHORT-NAME>DKMM_Sporadic_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <MINIMUM-DELAY>0.01</MINIMUM-DELAY>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/DKMM_Sporadic_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329fc1xOa505a3f19f25843c4b329fd700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSpcID</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b302921XOa505a3f19f25843c4b30292000">
              <SHORT-NAME>ECM_010ms_PDU00</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <HEADER-ID-SHORT-HEADER>75520</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.005</TIMEOUT>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/ECM_010ms_Group00_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/ECM_010ms_Group00_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_010ms_PDU00/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.01</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b30298600">
                  <SHORT-NAME>ECM_010ms_Group00_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b3029a100">
                  <SHORT-NAME>ECM_010ms_Group00_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b3029d700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b30293b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnRunA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b3029f200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b30296b00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a2800">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClOpenReqA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302aaf00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCtrlrRunCrkTrmlSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a5e00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIntlckRelayAuth</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a7900">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtCrkAbotd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a9400">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtRunAbotd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302aca00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnTestMdEnbReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302ae500">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved39</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b3029bc00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnActuStdyStaToq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a4300">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpReqToTr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302a0d00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnCCMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b302b0000">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IECM_010ms_Group00_Reserved63</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b302921xOa505a3f19f25843c4b30295700">
                  <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IECM_010ms_Group00</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b305df5XOa505a3f19f25843c4b305df400">
              <SHORT-NAME>ECM_100ms_PDU10</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>75536</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/AmbtTemSnsrFlrSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/AmbtTemSnsrFlrStsInvsn</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/CoolngFanLvlFdbk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/CoolngFanPWMFdbk</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/EnDrvngCycCrtra</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/EnEleclMainWtrPumpActuSpd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/FuelSysVentCmdd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/FuelSysVentFltA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/IUPRDnmtrIncmntd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/IUPRDnmtrInh</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/IUPREnStFnshd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/PrmntDTCDrvngCycCrtra</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU10/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305f5c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILowTemWtrPumpAfterRunLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305ed500">
                  <SHORT-NAME>AmbtTemSnsrFlrStsInvsn</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAmbtTemSnsrFlrStsInvsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305f0b00">
                  <SHORT-NAME>AmbtTemSnsrFlrSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAmbtTemSnsrFlrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305ef000">
                  <SHORT-NAME>EnEleclMainWtrPumpActuSpd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnEleclMainWtrPumpActuSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305eba00">
                  <SHORT-NAME>CoolngFanPWMFdbk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICoolngFanPWMFdbk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e8400">
                  <SHORT-NAME>FuelSysVentCmdd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFuelSysVentCmdd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e6900">
                  <SHORT-NAME>PrmntDTCDrvngCycCrtra</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPrmntDTCDrvngCycCrtra</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e9f00">
                  <SHORT-NAME>FuelSysVentFltA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFuelSysVentFltA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e1700">
                  <SHORT-NAME>EnDrvngCycCrtra</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnDrvngCycCrtra</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305f4100">
                  <SHORT-NAME>IUPREnStFnshd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIUPREnStFnshd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e3300">
                  <SHORT-NAME>IUPRDnmtrIncmntd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIUPRDnmtrIncmntd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305e4e00">
                  <SHORT-NAME>IUPRDnmtrInh</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIUPRDnmtrInh</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305df5xOa505a3f19f25843c4b305f2600">
                  <SHORT-NAME>CoolngFanLvlFdbk</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICoolngFanLvlFdbk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b305f8cXOa505a3f19f25843c4b305f8b00">
              <SHORT-NAME>ECM_100ms_PDU11</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>75537</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/EnSpdOBD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU11/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b30605000">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnClntTrtTem</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b305fc900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTClntPumpSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b305fff00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSClntPumpSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b305fe400">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTElecWtrPumpTrgtSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b30601a00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSElecWtrPumpTrgtSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b30603500">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICoolngFanWorkSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b30606b00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILowTemWtrPumpTrgtSpd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b305f8cxOa505a3f19f25843c4b305fae00">
                  <SHORT-NAME>EnSpdOBD</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEnSpdOBD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3026c0XOa505a3f19f25843c4b3026bf00">
              <SHORT-NAME>ECM_100ms_PDU12</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>75538</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.085</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/AccelAbsPosOBD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/ECMCoolngFanPWMReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/ECMCoolngFanPWMReqV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/EnCalcLdValOBD</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/EnFuelCsumpEfncy</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/FuelCsump</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/VehRfulSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ECM_100ms_PDU12/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3026c0xOa505a3f19f25843c4b3027d600">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRVSPtRunAbotdRsn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>5</START-POSITION>
