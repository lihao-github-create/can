                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved51</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved63</SHORT-LABEL>
                              <VALUE>0x7</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group02_Reserved57</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb487d00">
                  <SHORT-NAME>SDM_20ms_Group03</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_CRC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_RC
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_Reserved1
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_Reserved2
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_Reserved3
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_SDM_20ms_Group03_Reserved4
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSELatAccV_SDM
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSELatAcc_SDM
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSELongtAccV_SDM
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VSELongtAcc_SDM
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VehDynYawRateV_SDM
20250508_00-20250507NGMG6阶段性导出BaseOnSVWAAGT2高配.xlsx_VehDynYawRate_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VehDynYawRate_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VehDynYawRateV_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VSELatAcc_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VSELatAccV_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VSELongtAcc_SDM
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx_VSELongtAccV_SDM
20250818_IP5PM EP 信号变更--后续整理 --20250818.xlsx_VSELatAccV_SDM
20250818_IP5PM EP 信号变更--后续整理 --20250818.xlsx_VSELatAcc_SDM
20250818_IP5PM EP 信号变更--后续整理 --20250818.xlsx_VSELongtAccV_SDM
20250818_IP5PM EP 信号变更--后续整理 --20250818.xlsx_VSELongtAcc_SDM
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VSELatAccV_SDM
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VSELatAcc_SDM
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VSELongtAccV_SDM
20250825_20250820-D5X Simu EV CANLIN信号导出表base.xlsx_VSELongtAcc_SDM
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_VSELatAcc_SDM
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_VSELatAccV_SDM
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_VSELongtAcc_SDM
20250827_202508206-D5X Simu EV CANLIN信号导出表阶段.xlsx_VSELongtAccV_SDM
20251119_AS5PR EV高阶未实施需求.xlsx_VSELatAcc_SDM
20251119_AS5PR EV高阶未实施需求.xlsx_VSELongtAccV_SDM
20251119_AS5PR EV高阶未实施需求.xlsx_VSELongtAcc_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehDynYawRate_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VehDynYawRateV_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSELatAcc_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSELatAccV_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSELongtAcc_SDM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_VSELongtAccV_SDM
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VSELongtAcc_SDM
20260408_20260408-AS5PR EV-PPV-V1.0.xlsx_VSELongtAccV_SDM
20260706_modify.xlsx_VSELatAcc_SDM
20260706_modify.xlsx_VSELongtAcc_SDM</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group03/SDM_20ms_Group03</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SDM_20ms_Group03</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehDynYawRate_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehDynYawRateV_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSELatAcc_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSELatAccV_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSELongtAcc_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VSELongtAccV_SDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_Reserved1</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_Reserved3</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SDM_20ms_Group03_Reserved4</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SDM_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb96c400">
                  <SHORT-NAME>SLIFUpdtIndReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251119_AS5PR EV高阶未实施需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFUpdtIndReq/SLIFUpdtIndReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFUpdtIndReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb935800">
                  <SHORT-NAME>SLIFWrnngMdReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251118_AS5P EP-CAN-EV.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SLIFWrnngMdReq/SLIFWrnngMdReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SLIFWrnngMdReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb84bc00">
                  <SHORT-NAME>SOCLowPwrDwn_flg</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCLowPwrDwn_flg/SOCLowPwrDwn_flg</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SOCLowPwrDwn_flg</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLowPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb84e300">
                  <SHORT-NAME>SOCLvl_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCLvl_enum/SOCLvl_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SOCLvl_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCLvl_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb850a00">
                  <SHORT-NAME>SOCMd_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SOCMd_enum/SOCMd_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SOCMd_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SOCMd_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4dd100">
                  <SHORT-NAME>SatAz1</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz1/SatAz1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4df800">
                  <SHORT-NAME>SatAz10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz10/SatAz10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz10</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4e1f00">
                  <SHORT-NAME>SatAz11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz11/SatAz11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz11</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4e4600">
                  <SHORT-NAME>SatAz12</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz12/SatAz12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz12</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4e6d00">
                  <SHORT-NAME>SatAz13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz13/SatAz13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz13</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4e9400">
                  <SHORT-NAME>SatAz14</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz14/SatAz14</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz14</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4ebb00">
                  <SHORT-NAME>SatAz15</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz15/SatAz15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz15</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4ee200">
                  <SHORT-NAME>SatAz16</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz16/SatAz16</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz16</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4f0900">
                  <SHORT-NAME>SatAz17</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz17/SatAz17</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz17</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4f3000">
                  <SHORT-NAME>SatAz18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz18/SatAz18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz18</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4f5700">
                  <SHORT-NAME>SatAz19</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz19/SatAz19</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz19</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4f7e00">
                  <SHORT-NAME>SatAz2</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz2/SatAz2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4fa500">
                  <SHORT-NAME>SatAz20</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz20/SatAz20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz20</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4fcc00">
                  <SHORT-NAME>SatAz3</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz3/SatAz3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb4ff300">
                  <SHORT-NAME>SatAz4</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz4/SatAz4</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz4</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb501a00">
                  <SHORT-NAME>SatAz5</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz5/SatAz5</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz5</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb504100">
                  <SHORT-NAME>SatAz6</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz6/SatAz6</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz6</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb506800">
                  <SHORT-NAME>SatAz7</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz7/SatAz7</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz7</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb508f00">
                  <SHORT-NAME>SatAz8</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz8/SatAz8</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz8</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb50b600">
                  <SHORT-NAME>SatAz9</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatAz9/SatAz9</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatAz9</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatAz9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb50dd00">
                  <SHORT-NAME>SatCNO1</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO1/SatCNO1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb510400">
                  <SHORT-NAME>SatCNO10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO10/SatCNO10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO10</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb512b00">
                  <SHORT-NAME>SatCNO11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO11/SatCNO11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO11</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb515200">
                  <SHORT-NAME>SatCNO12</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO12/SatCNO12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO12</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb517900">
                  <SHORT-NAME>SatCNO13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO13/SatCNO13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO13</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb51a000">
                  <SHORT-NAME>SatCNO14</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO14/SatCNO14</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO14</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb51c700">
                  <SHORT-NAME>SatCNO15</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO15/SatCNO15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO15</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb51ee00">
                  <SHORT-NAME>SatCNO16</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO16/SatCNO16</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO16</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb521500">
                  <SHORT-NAME>SatCNO17</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO17/SatCNO17</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO17</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb523c00">
                  <SHORT-NAME>SatCNO18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO18/SatCNO18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO18</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb526300">
                  <SHORT-NAME>SatCNO19</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO19/SatCNO19</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO19</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb528a00">
                  <SHORT-NAME>SatCNO2</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO2/SatCNO2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb52b100">
                  <SHORT-NAME>SatCNO20</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO20/SatCNO20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO20</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb52d800">
                  <SHORT-NAME>SatCNO3</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO3/SatCNO3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb52ff00">
                  <SHORT-NAME>SatCNO4</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO4/SatCNO4</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO4</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb532600">
                  <SHORT-NAME>SatCNO5</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO5/SatCNO5</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO5</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb534d00">
                  <SHORT-NAME>SatCNO6</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO6/SatCNO6</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO6</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb537400">
                  <SHORT-NAME>SatCNO7</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO7/SatCNO7</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO7</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb539b00">
                  <SHORT-NAME>SatCNO8</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO8/SatCNO8</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO8</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb53c200">
                  <SHORT-NAME>SatCNO9</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatCNO9/SatCNO9</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatCNO9</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatCNO9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb53e900">
                  <SHORT-NAME>SatElv1</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv1/SatElv1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb541000">
                  <SHORT-NAME>SatElv10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv10/SatElv10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv10</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb543700">
                  <SHORT-NAME>SatElv11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv11/SatElv11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv11</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb545e00">
                  <SHORT-NAME>SatElv12</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv12/SatElv12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv12</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb548500">
                  <SHORT-NAME>SatElv13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv13/SatElv13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv13</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb54ac00">
                  <SHORT-NAME>SatElv14</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv14/SatElv14</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv14</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb54d300">
                  <SHORT-NAME>SatElv15</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv15/SatElv15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv15</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb54fa00">
                  <SHORT-NAME>SatElv16</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv16/SatElv16</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv16</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb552100">
                  <SHORT-NAME>SatElv17</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv17/SatElv17</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv17</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb554800">
                  <SHORT-NAME>SatElv18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv18/SatElv18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv18</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb556f00">
                  <SHORT-NAME>SatElv19</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv19/SatElv19</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv19</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb559600">
                  <SHORT-NAME>SatElv2</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv2/SatElv2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb55bd00">
                  <SHORT-NAME>SatElv20</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv20/SatElv20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv20</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb55e400">
                  <SHORT-NAME>SatElv3</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv3/SatElv3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb560b00">
                  <SHORT-NAME>SatElv4</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv4/SatElv4</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv4</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb563200">
                  <SHORT-NAME>SatElv5</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv5/SatElv5</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv5</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb565900">
                  <SHORT-NAME>SatElv6</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv6/SatElv6</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv6</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb568000">
                  <SHORT-NAME>SatElv7</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv7/SatElv7</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv7</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb56a700">
                  <SHORT-NAME>SatElv8</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv8/SatElv8</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv8</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb56ce00">
                  <SHORT-NAME>SatElv9</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatElv9/SatElv9</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatElv9</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatElv9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb56f500">
                  <SHORT-NAME>SatID1</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID1/SatID1</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID1</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb571c00">
                  <SHORT-NAME>SatID10</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID10/SatID10</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID10</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb574300">
                  <SHORT-NAME>SatID11</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID11/SatID11</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID11</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb576a00">
                  <SHORT-NAME>SatID12</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID12/SatID12</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID12</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb579100">
                  <SHORT-NAME>SatID13</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID13/SatID13</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID13</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb57b800">
                  <SHORT-NAME>SatID14</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID14/SatID14</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID14</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID14</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb57df00">
                  <SHORT-NAME>SatID15</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID15/SatID15</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID15</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb580600">
                  <SHORT-NAME>SatID16</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID16/SatID16</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID16</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb582d00">
                  <SHORT-NAME>SatID17</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID17/SatID17</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID17</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb585400">
                  <SHORT-NAME>SatID18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID18/SatID18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID18</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb587b00">
                  <SHORT-NAME>SatID19</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID19/SatID19</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID19</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb58a200">
                  <SHORT-NAME>SatID2</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID2/SatID2</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID2</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb58c900">
                  <SHORT-NAME>SatID20</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID20/SatID20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID20</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb58f000">
                  <SHORT-NAME>SatID3</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID3/SatID3</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID3</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID3</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb591700">
                  <SHORT-NAME>SatID4</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID4/SatID4</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID4</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID4</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb593e00">
                  <SHORT-NAME>SatID5</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID5/SatID5</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID5</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID5</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb596500">
                  <SHORT-NAME>SatID6</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID6/SatID6</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID6</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID6</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb598c00">
                  <SHORT-NAME>SatID7</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID7/SatID7</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID7</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID7</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb59b300">
                  <SHORT-NAME>SatID8</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID8/SatID8</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID8</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID8</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb59da00">
                  <SHORT-NAME>SatID9</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatID9/SatID9</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatID9</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatID9</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5a0100">
                  <SHORT-NAME>SatNoInAttitudeRTK</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNoInAttitudeRTK/SatNoInAttitudeRTK</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatNoInAttitudeRTK</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInAttitudeRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5a2800">
                  <SHORT-NAME>SatNoInPositionRTK</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNoInPositionRTK/SatNoInPositionRTK</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatNoInPositionRTK</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNoInPositionRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5a4f00">
                  <SHORT-NAME>SatNum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SatNum/SatNum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SatNum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SatNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba5c900">
                  <SHORT-NAME>SeatOccptnNum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260304_20260304-路由纠错.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SeatOccptnNum/SeatOccptnNum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SeatOccptnNum</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SeatOccptnNum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb853100">
                  <SHORT-NAME>ShftSeqStat_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ShftSeqStat_enum/ShftSeqStat_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>ShftSeqStat_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ShftSeqStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb61fd00">
                  <SHORT-NAME>SideLghtSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V1.xlsx
20250614_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250818_IP5PM EP 信号变更--后续整理 --20250818.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SideLghtSts/SideLghtSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SideLghtSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SideLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb23b2100">
                  <SHORT-NAME>SpdLmtNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtNav/SpdLmtNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtNav</SHORT-LABEL>
                          <VALUE>0x1F</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2a4900">
                  <SHORT-NAME>SpdLmtOfstSetNumReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumReq/SpdLmtOfstSetNumReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetNumReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2a7000">
                  <SHORT-NAME>SpdLmtOfstSetPercReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250311_PT信号总表.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercReq/SpdLmtOfstSetPercReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetPercReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2a9700">
                  <SHORT-NAME>SpdLmtOfstSetReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250526_IP5PM EP信号需求V4---梳理.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtOfstSetReq/SpdLmtOfstSetReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtOfstSetReq</SHORT-LABEL>
                          <VALUE>0x14</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f34f4acdb235a700">
                  <SHORT-NAME>SpdLmtPathRngNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpdLmtPathRngNav/SpdLmtPathRngNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpdLmtPathRngNav</SHORT-LABEL>
                          <VALUE>0x7FF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtPathRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb67c600">
                  <SHORT-NAME>SpedRegulaModSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SpedRegulaModSwReq/SpedRegulaModSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SpedRegulaModSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb855800">
                  <SHORT-NAME>StrtTypAvail_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/StrtTypAvail_enum/StrtTypAvail_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>StrtTypAvail_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/StrtTypAvail_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5a7600">
                  <SHORT-NAME>SvGroup</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SvGroup/SvGroup</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>SvGroup</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SvGroup</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb857f00">
                  <SHORT-NAME>TASSAMTqSplt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TASSAMTqSplt_Nm/TASSAMTqSplt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TASSAMTqSplt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASSAMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb85a600">
                  <SHORT-NAME>TASTMTqSplt_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TASTMTqSplt_Nm/TASTMTqSplt_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TASTMTqSplt_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TASTMTqSplt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9db600">
                  <SHORT-NAME>TCM_020ms_PDU18</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_SCUAPAUnderCtrlA_TCM
20251210_D5X EV 对比信号需求.xlsx_SCUDrvrIntrvnA_TCM
20251217_D5X EV 对比信号需求-2021217.xlsx_CluActTorq
20251217_D5X EV 对比信号需求-2021217.xlsx_TCM_020ms_PDU18_CRC
20251217_D5X EV 对比信号需求-2021217.xlsx_TCM_020ms_PDU18_RC
20251217_D5X EV 对比信号需求-2021217.xlsx_TCM_020ms_PDU18_Reserve01
20251217_D5X EV 对比信号需求-2021217.xlsx_TCM_020ms_PDU18_Reserve02
20251217_D5X EV 对比信号需求-2021217.xlsx_TCM_020ms_PDU18_Reserve03
20251217_D5X EV 对比信号需求-2021217.xlsx_TrAPACanclReq</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_020ms_PDU18/TCM_020ms_PDU18</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCM_020ms_PDU18</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUAPAUnderCtrlA_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>SCUDrvrIntrvnA_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>CluActTorq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_020ms_PDU18_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_020ms_PDU18_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_020ms_PDU18_Reserve01</SHORT-LABEL>
                              <VALUE>0x7F</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_020ms_PDU18_Reserve02</SHORT-LABEL>
                              <VALUE>0xFFFFFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_020ms_PDU18_Reserve03</SHORT-LABEL>
                              <VALUE>0xF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrAPACanclReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_020ms_PDU18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9ddd00">
                  <SHORT-NAME>TCM_025ms_Group02</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251210_D5X EV 对比信号需求.xlsx_AutocTrCmddGear_TCM
20251210_D5X EV 对比信号需求.xlsx_DrvrShftCtrlReqDndIO
20251210_D5X EV 对比信号需求.xlsx_DrvrShftCtrlTrgtGear_TCM
20251210_D5X EV 对比信号需求.xlsx_TCM_025ms_Group02_Reserved1
20251210_D5X EV 对比信号需求.xlsx_TCM_025ms_Group02_Reserved2
20251210_D5X EV 对比信号需求.xlsx_TCM_025ms_Group02_Reserved3
20251210_D5X EV 对比信号需求.xlsx_TCM_025ms_PDU02_CRC
20251210_D5X EV 对比信号需求.xlsx_TCM_025ms_PDU02_RC
20251210_D5X EV 对比信号需求.xlsx_TrCrpMdA_TCM
20251210_D5X EV 对比信号需求.xlsx_TrEPBAppReq
20251210_D5X EV 对比信号需求.xlsx_TrEngdStaV_TCM
20251210_D5X EV 对比信号需求.xlsx_TrEngdSta_TCM
20251210_D5X EV 对比信号需求.xlsx_TrEstdGearV_TCM
20251210_D5X EV 对比信号需求.xlsx_TrEstdGear_TCM
20251210_D5X EV 对比信号需求.xlsx_TrIntnlSwPos
20251210_D5X EV 对比信号需求.xlsx_TrIntnlSwPosV
20251210_D5X EV 对比信号需求.xlsx_TrPrkPos
20251210_D5X EV 对比信号需求.xlsx_TrPrkSysF
20251210_D5X EV 对比信号需求.xlsx_TrShftLvrPosV_TCM
20251210_D5X EV 对比信号需求.xlsx_TrShftLvrPos_TCM
20251210_D5X EV 对比信号需求.xlsx_TrShftPtrnASts_TCM
20251210_D5X EV 对比信号需求.xlsx_TrTapUpTapDwnMdSts_TCM
20251210_D5X EV 对比信号需求.xlsx_TrTrgtShftLvrPos
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPos_TCM
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx_TrShftLvrPosV_TCM</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_025ms_Group02/TCM_025ms_Group02</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCM_025ms_Group02</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrShftLvrPosV_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrShftLvrPos_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU02_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU02_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>AutocTrCmddGear_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrShftCtrlReqDndIO</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>DrvrShftCtrlTrgtGear_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrCrpMdA_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEngdSta_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEngdStaV_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEPBAppReq</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEstdGear_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrEstdGearV_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrIntnlSwPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrIntnlSwPosV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPrkPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPrkSysF</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrShftPtrnASts_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrTapUpTapDwnMdSts_TCM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrTrgtShftLvrPos</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_Group02_Reserved1</SHORT-LABEL>
                              <VALUE>0x3</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_Group02_Reserved2</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_Group02_Reserved3</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f5902a13b3685a00">
                  <SHORT-NAME>TCM_025ms_PDU20</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_CRC
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_RC
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_Reserve01
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_Reserve02
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_Reserve03
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU20_Reserve04
20260713_11-李-260713-groupTCM.xlsx_TrACCToqReqResp</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_025ms_PDU20/TCM_025ms_PDU20</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCM_025ms_PDU20</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_Reserve01</SHORT-LABEL>
                              <VALUE>0xFFFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_Reserve02</SHORT-LABEL>
                              <VALUE>0xFFFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_Reserve03</SHORT-LABEL>
                              <VALUE>0x1</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU20_Reserve04</SHORT-LABEL>
                              <VALUE>0xFFFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrACCToqReqResp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_025ms_PDU20</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f5902a13b3663d00">
                  <SHORT-NAME>TCM_PTCAN_FrP05</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU05_CRC
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU05_RC
20260713_11-李-260713-groupTCM.xlsx_TCM_025ms_PDU05_Reserve01
20260713_11-李-260713-groupTCM.xlsx_TrGear
20260713_11-李-260713-groupTCM.xlsx_TrGearV
20260713_11-李-260713-groupTCM.xlsx_TrImmdCrkshftToqReqVal
20260713_11-李-260713-groupTCM.xlsx_TrImmdCrkshftToqRespTyp
20260713_11-李-260713-groupTCM.xlsx_TrPrdtdCrkshftToqIntrvnTyp
20260713_11-李-260713-groupTCM.xlsx_TrPrdtdCrkshftToqReqV</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_PTCAN_FrP05/TCM_PTCAN_FrP05</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCM_PTCAN_FrP05</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU05_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU05_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TCM_025ms_PDU05_Reserve01</SHORT-LABEL>
                              <VALUE>0x1FFF</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrGear</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrGearV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrImmdCrkshftToqReqVal</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrImmdCrkshftToqRespTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPrdtdCrkshftToqIntrvnTyp</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrPrdtdCrkshftToqReqV</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCM_PTCAN_FrP05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb85cd00">
                  <SHORT-NAME>TCUIntvSAMTq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUIntvSAMTq_Nm/TCUIntvSAMTq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCUIntvSAMTq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvSAMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb85f400">
                  <SHORT-NAME>TCUIntvTMTq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUIntvTMTq_Nm/TCUIntvTMTq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCUIntvTMTq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUIntvTMTq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb861b00">
                  <SHORT-NAME>TCUOpSt_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCUOpSt_enum/TCUOpSt_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TCUOpSt_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TCUOpSt_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9e2700">
                  <SHORT-NAME>TDMAvlbly</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251216_D5X EV 对比信号需求-2021216.xlsx
20260604_AS5PR EV增补.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TDMAvlbly/TDMAvlbly</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TDMAvlbly</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba5f000">
                  <SHORT-NAME>TDM_200ms_Group01</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260305_20260304-路由纠错.xlsx_TrlrCnctSts
20260604_AS5PR EV增补.xlsx_TrlrCnctSts
20260604_AS5PR EV增补.xlsx_BrkLghtF_TDM
20260604_AS5PR EV增补.xlsx_BrkLghtOn_TDM
20260604_AS5PR EV增补.xlsx_LDircnIO_TDM
20260604_AS5PR EV增补.xlsx_LDircnIndLghtF_TDM
20260604_AS5PR EV增补.xlsx_RDircnIO_TDM
20260604_AS5PR EV增补.xlsx_RDircnIndLghtF_TDM
20260604_AS5PR EV增补.xlsx_RevsLghtF_TDM
20260604_AS5PR EV增补.xlsx_RevsLghtOn_TDM
20260604_AS5PR EV增补.xlsx_RrFogLghtF_TDM
20260604_AS5PR EV增补.xlsx_RrFogLghtOn_TDM
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_CRC
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_RC
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved103
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved111
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved119
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved127
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved15
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved27
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved39
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved47
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved55
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved63
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved71
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved79
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved87
20260604_AS5PR EV增补.xlsx_TDM_200ms_Group01_Reserved95
20260604_AS5PR EV增补.xlsx_VehSideLghtSts_TDM
20260703_modify.xlsx_RevsLghtOn_TDM</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TDM_200ms_Group01/TDM_200ms_Group01</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <RECORD-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TDM_200ms_Group01</SHORT-LABEL>
                          <FIELDS>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtF_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>BrkLghtOn_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDircnIndLghtF_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>LDircnIO_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDircnIndLghtF_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RDircnIO_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RevsLghtF_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RevsLghtOn_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrFogLghtF_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>RrFogLghtOn_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TrlrCnctSts</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>VehSideLghtSts_TDM</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_CRC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_RC</SHORT-LABEL>
                              <VALUE>0x0</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved15</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved27</SHORT-LABEL>
                              <VALUE>0xf</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved39</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved47</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved55</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved63</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved71</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved79</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved87</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved95</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved103</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved111</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved119</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                            <NUMERICAL-VALUE-SPECIFICATION>
                              <SHORT-LABEL>TDM_200ms_Group01_Reserved127</SHORT-LABEL>
                              <VALUE>0xff</VALUE>
                            </NUMERICAL-VALUE-SPECIFICATION>
                          </FIELDS>
                        </RECORD-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TDM_200ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2abe00">
                  <SHORT-NAME>TLRMdSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TLRMdSwReq/TLRMdSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TLRMdSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9a4500">
                  <SHORT-NAME>TPMSBtmNosRSSI</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSBtmNosRSSI/TPMSBtmNosRSSI</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSBtmNosRSSI</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSBtmNosRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9a6c00">
                  <SHORT-NAME>TPMSSnsrID</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrID/TPMSSnsrID</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSSnsrID</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9a9300">
                  <SHORT-NAME>TPMSSnsrIDLoctn</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrIDLoctn/TPMSSnsrIDLoctn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSSnsrIDLoctn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrIDLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9aba00">
                  <SHORT-NAME>TPMSSnsrRSSI</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRSSI/TPMSSnsrRSSI</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSSnsrRSSI</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRSSI</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9ae100">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtr</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtr/TPMSSnsrRdoFrqcCtr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSSnsrRdoFrqcCtr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9b0800">
                  <SHORT-NAME>TPMSSnsrRdoFrqcCtrLoctn</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtrLoctn/TPMSSnsrRdoFrqcCtrLoctn</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSSnsrRdoFrqcCtrLoctn</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSSnsrRdoFrqcCtrLoctn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb9b2f00">
                  <SHORT-NAME>TPMSWntrMdA</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TPMSWntrMdA/TPMSWntrMdA</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TPMSWntrMdA</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TPMSWntrMdA</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb864200">
                  <SHORT-NAME>TQRTMTqReq_N</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TQRTMTqReq_N/TQRTMTqReq_N</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TQRTMTqReq_N</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TQRTMTqReq_N</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb866900">
                  <SHORT-NAME>TRCEMTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TRCEMTqReq_Nm/TRCEMTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TRCEMTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb869000">
                  <SHORT-NAME>TRCTqDmdSTC_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TRCTqDmdSTC_Nm/TRCTqDmdSTC_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TRCTqDmdSTC_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TRCTqDmdSTC_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2ae500">
                  <SHORT-NAME>TSRSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TSRSwReq/TSRSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TSRSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb86b700">
                  <SHORT-NAME>TZXEMMaxTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TZXEMMaxTqReq_Nm/TZXEMMaxTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TZXEMMaxTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMMaxTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb86de00">
                  <SHORT-NAME>TZXEMTqReq_Nm</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TZXEMTqReq_Nm/TZXEMTqReq_Nm</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TZXEMTqReq_Nm</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TZXEMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bbadd000">
                  <SHORT-NAME>TemSnsrHdwrFltPrst</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260506_20260506-AS5PR EV-PPV-V1.2.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TemSnsrHdwrFltPrst/TemSnsrHdwrFltPrst</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TemSnsrHdwrFltPrst</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TemSnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb870500">
                  <SHORT-NAME>TqCtrlStat_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TqCtrlStat_enum/TqCtrlStat_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TqCtrlStat_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TqCtrlStat_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba92200">
                  <SHORT-NAME>TrdtnKeyBtnSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnKeyBtnSts/TrdtnKeyBtnSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrdtnKeyBtnSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnKeyBtnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba8d400">
                  <SHORT-NAME>TrdtnSmrtKyFindCarSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyFindCarSwSts/TrdtnSmrtKyFindCarSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrdtnSmrtKyFindCarSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyFindCarSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba88600">
                  <SHORT-NAME>TrdtnSmrtKyLckSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260408_20260408-AS5PR EV-PPV-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLckSwSts/TrdtnSmrtKyLckSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrdtnSmrtKyLckSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba8fb00">
                  <SHORT-NAME>TrdtnSmrtKyLdspcSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260409_20260408-AS5PR EV-PPV-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLdspcSwSts/TrdtnSmrtKyLdspcSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrdtnSmrtKyLdspcSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyLdspcSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba8ad00">
                  <SHORT-NAME>TrdtnSmrtKyUnlckSwSts</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260408_20260408-AS5PR EV-PPV-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrdtnSmrtKyUnlckSwSts/TrdtnSmrtKyUnlckSwSts</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrdtnSmrtKyUnlckSwSts</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrdtnSmrtKyUnlckSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6a0f00">
                  <SHORT-NAME>TrfcForbidDist</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcForbidDist/TrfcForbidDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcForbidDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcForbidDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb6a3600">
                  <SHORT-NAME>TrfcInfoSignDist</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcInfoSignDist/TrfcInfoSignDist</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcInfoSignDist</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcInfoSignDist</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb7c0d00">
                  <SHORT-NAME>TrfcJamRngNav</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcJamRngNav/TrfcJamRngNav</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcJamRngNav</SHORT-LABEL>
                          <VALUE>0xFF</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcJamRngNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb68d700">
                  <SHORT-NAME>TrfcLghtFuctionSwReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250606_IP5PM EP信号需求V5-输出V1--梳理V2-add.xlsx
20260703_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwReq/TrfcLghtFuctionSwReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TrfcLghtFuctionSwReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5ed300">
                  <SHORT-NAME>TripCnt</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx
20260528_新增接收2.xlsx
20260703_modify.xlsx
20260706_modify.xlsx
20260707_modify.xlsx
20260715_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TripCnt/TripCnt</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TripCnt</SHORT-LABEL>
                          <VALUE>0x1</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5f1f00">
                  <SHORT-NAME>TripCntResetReq</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250527_IP5PM EP信号需求V4---梳理.xlsx
20260528_新增接收2.xlsx
20260706_modify.xlsx
20260707_modify.xlsx
20260715_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TripCntResetReq/TripCntResetReq</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>TripCntResetReq</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TripCntResetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb872c00">
                  <SHORT-NAME>VDCSlipCtrlSts_enum</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250615_Add-IP5PM EP信号需求-EV高阶-输出-梳理-Add.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VDCSlipCtrlSts_enum/VDCSlipCtrlSts_enum</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VDCSlipCtrlSts_enum</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VDCSlipCtrlSts_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2b0c00">
                  <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250311_PT信号总表.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshDay/VehTiPblshDay</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshDay</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshDay</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2b3300">
                  <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250311_PT信号总表.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshHr/VehTiPblshHr</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshHr</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshHr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2b5a00">
                  <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250311_PT信号总表.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshMins/VehTiPblshMins</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshMins</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMins</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2b8100">
                  <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshMth/VehTiPblshMth</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshMth</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshMth</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2ba800">
                  <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshSec/VehTiPblshSec</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshSec</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshSec</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb2bcf00">
                  <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20241119_副本总表_0.4_20241118.xlsx
20250615_IP5PM EP信号需求-EV高阶-输出-梳理.xlsx
20250826_20250820-D5X Simu EV CANLIN信号导出表base.xlsx
20251114_EP--AS5PR_EV高阶_20251107.xlsx
20251202_20251201-bl1-AS5PR EV高阶打包表-网络管理信号需求.xlsx
20251222_D5X-接收网段-2025-12-22.xlsx
20251229_AS5PR&amp;AS5PM EP计划外需求-EV实施-20251226.msg.xlsx
20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx
20260302_20260301-AS4PR EV-补充漏收-V1.0.xlsx
20260706_modify.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/VehTiPblshYear/VehTiPblshYear</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>VehTiPblshYear</SHORT-LABEL>
                          <VALUE>0x13</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/VehTiPblshYear</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5ac400">
                  <SHORT-NAME>Veldownsigma</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Veldownsigma/Veldownsigma</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Veldownsigma</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veldownsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5aeb00">
                  <SHORT-NAME>Veleastsigma</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Veleastsigma/Veleastsigma</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Veleastsigma</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Veleastsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb5b1200">
                  <SHORT-NAME>Velnorthsigma</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20250522_IP5PM EP信号需求--ADD.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/Velnorthsigma/Velnorthsigma</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>Velnorthsigma</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Velnorthsigma</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba20100">
                  <SHORT-NAME>WhlRghRoad</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/WhlRghRoad/WhlRghRoad</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>WhlRghRoad</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bba22800">
                  <SHORT-NAME>WhlRghRoadV</SHORT-NAME>
                  <DESC>
                    <L-2 L="EN">20260213_20260211-AS5PR EV-EP2-信号需求-V1.0.xlsx</L-2>
                  </DESC>
                  <REQUIRED-COM-SPECS>
                    <NONQUEUED-RECEIVER-COM-SPEC>
                      <DATA-ELEMENT-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/WhlRghRoadV/WhlRghRoadV</DATA-ELEMENT-REF>
                      <INIT-VALUE>
                        <NUMERICAL-VALUE-SPECIFICATION>
                          <SHORT-LABEL>WhlRghRoadV</SHORT-LABEL>
                          <VALUE>0x0</VALUE>
                        </NUMERICAL-VALUE-SPECIFICATION>
                      </INIT-VALUE>
                    </NONQUEUED-RECEIVER-COM-SPEC>
                  </REQUIRED-COM-SPECS>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/WhlRghRoadV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
              </PORTS>
              <INTERNAL-BEHAVIORS>
                <SWC-INTERNAL-BEHAVIOR UUID="Na505a3f19f25843c4bb26ffxNa505a3f19f25843c4bb270a00">
                  <SHORT-NAME>InternalBehavior26</SHORT-NAME>
                  <DATA-TYPE-MAPPING-REFS>
                    <DATA-TYPE-MAPPING-REF DEST="DATA-TYPE-MAPPING-SET">/DataTypeMappingSets/Data_Type_Mappings2</DATA-TYPE-MAPPING-REF>
                  </DATA-TYPE-MAPPING-REFS>
                </SWC-INTERNAL-BEHAVIOR>
              </INTERNAL-BEHAVIORS>
            </APPLICATION-SW-COMPONENT-TYPE>
            <COMPOSITION-SW-COMPONENT-TYPE UUID="Na505a3f19f25843c4b1dacbXNa505a3f19f25843c4b1daca00">
              <SHORT-NAME>IPDEcuComp</SHORT-NAME>
              <PORTS>
                <P-PORT-PROTOTYPE UUID="49383b78a91030fc8799af466cb685b6">
                  <SHORT-NAME>ACCConfmSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCConfmSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="819bb87366363b2eb63af2a4cbb1752c">
                  <SHORT-NAME>ACCCurveSpdSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCCurveSpdSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="81c55d08979f3a91a0f08505431347a9">
                  <SHORT-NAME>ACCDetObj1ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5dfc463335f63cb7bea76418e3117972">
                  <SHORT-NAME>ACCDetObj1Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e5fdc504f4b335d08b584aa4816d90de">
                  <SHORT-NAME>ACCDetObj1LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c66922e037e03360a04a36b9452552a2">
                  <SHORT-NAME>ACCDetObj1LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3e4b923da082384cb9e24144144ef843">
                  <SHORT-NAME>ACCDetObj1LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="15851320439b32a687520d94e12c32b0">
                  <SHORT-NAME>ACCDetObj1Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="259e56f4fbd232029ff88a6c52eae935">
                  <SHORT-NAME>ACCDetObj1SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c76486ecce32373ca807a535bdc50c77">
                  <SHORT-NAME>ACCDetObj1Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj1Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e9d79ef25111372c8a929579217e54c8">
                  <SHORT-NAME>ACCDetObj2ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a03a62c3e933607a78bb4c5bd0fd504">
                  <SHORT-NAME>ACCDetObj2Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b49e1332a8e636e88ccba3458922dec9">
                  <SHORT-NAME>ACCDetObj2LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="32db5eb933e03d5c8b08b05b81054b89">
                  <SHORT-NAME>ACCDetObj2LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4d0bddbf2e6b38c2a235df1b828368fe">
                  <SHORT-NAME>ACCDetObj2LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="242e1f9c01d23fc3b8c929bc83e88172">
                  <SHORT-NAME>ACCDetObj2Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bf1320c6435335cdbf676f3ce4781f3e">
                  <SHORT-NAME>ACCDetObj2SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2d8504d85e923c318d658762666465c9">
                  <SHORT-NAME>ACCDetObj2Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj2Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fb9ff0fc49bc36288af61211bd42aafc">
                  <SHORT-NAME>ACCDetObj3ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="21043da21d773651b6df5831cfe3adfe">
                  <SHORT-NAME>ACCDetObj3Id</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Id</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="546d1a986b1a3c9995c4002433ef5972">
                  <SHORT-NAME>ACCDetObj3LatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ef510ca2cd1631aba7497404f8d77a30">
                  <SHORT-NAME>ACCDetObj3LongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e918dc3e75fd3a0bbc4bf3447ecd5d2a">
                  <SHORT-NAME>ACCDetObj3LongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="23fd09f60b1d3c13b32c0c1d6ff4ad26">
                  <SHORT-NAME>ACCDetObj3Risk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Risk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="45d850b3e64337ee8033222385d3083e">
                  <SHORT-NAME>ACCDetObj3SyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3SyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6cf780ba2ab23138a064b2071fbf28e8">
                  <SHORT-NAME>ACCDetObj3Typ</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObj3Typ</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="30d06d7014f1319fb287af3b1c11b1a9">
                  <SHORT-NAME>ACCDetObjExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5f57e068f8a33b289a5f60bff0837d66">
                  <SHORT-NAME>ACCDetObjHdngAng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjHdngAng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="979d6e9be3b53920b6fc2d38b4e9b31a">
                  <SHORT-NAME>ACCDetObjId</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjId</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e5397773633739bfa8a1573a758ea645">
                  <SHORT-NAME>ACCDetObjLatRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLatRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1384190b71ec3a0284efda1d05c0c87c">
                  <SHORT-NAME>ACCDetObjLongtRltvDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3cd8c2fb1218342ca80421c36f9a1953">
                  <SHORT-NAME>ACCDetObjLongtRltvSpd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvSpd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cb8da6b3ebff38ee8b080d6f3acfc820">
                  <SHORT-NAME>ACCDetObjRisk</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjRisk</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9e83a2d1a8013855869fb57104397e18">
                  <SHORT-NAME>ACCDetObjSyncCtr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjSyncCtr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="be8583bfc9023bf492942d46fe240d25">
                  <SHORT-NAME>ACCDetObjTyp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDetObjTyp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="55c65cafd2363531a4da780148a7660e">
                  <SHORT-NAME>ACCDrvrTkovReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCDrvrTkovReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="33a1f03f86ee37e5aa39ec177095f18d">
                  <SHORT-NAME>ACCObjDet</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCObjDet</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="875e473f42d23111a58d7ab8e78c74d5">
                  <SHORT-NAME>ACCSpdLimtSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCSpdLimtSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="155bc4d25b333a019d64d85be92e9e7b">
                  <SHORT-NAME>ACCStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d69a559682333b8383e47657c048851d">
                  <SHORT-NAME>ACCStsSw</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsSw</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="de71ecd340af341082da057d3f62d095">
                  <SHORT-NAME>ACSFCatgrAStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrAStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cfd8c00d456a3e6898d39ad668317e3f">
                  <SHORT-NAME>ACSFCatgrB1StsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrB1StsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8215c05079af3e62b02899f43b002bb7">
                  <SHORT-NAME>ACSFCatgrB2StsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrB2StsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="700d94e5adff3312b1088c0688a8c983">
                  <SHORT-NAME>ACSFCatgrCStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrCStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fce53344ed1d37869be05076212bd6c8">
                  <SHORT-NAME>ACSFCatgrDStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrDStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c3eb81a92d9b30c9a286346ae40e8d5a">
                  <SHORT-NAME>ACSFCatgrEStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACSFCatgrEStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2a563a40f7ec3bc780af2b2454da01ba">
                  <SHORT-NAME>ADAudioSWSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADAudioSWSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a17431fa2e63bf584458c69caf13a23">
                  <SHORT-NAME>ADS_ISAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b261fbe04d4136b58e5c361ad6c5a386">
                  <SHORT-NAME>ADS_ISASysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISASysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="81a6f01867ff3ba6a51245df4791215a">
                  <SHORT-NAME>ADS_ISASysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADS_ISASysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="739fa7ee0ede3deca383ec4b28ef7246">
                  <SHORT-NAME>AEBDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="80031133151d39d986ffcdc9acc33033">
                  <SHORT-NAME>AEBMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="21575ac950d83104af530dfe268ba128">
                  <SHORT-NAME>AEBStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0a842493a75f36708697d790cd283ff1">
                  <SHORT-NAME>AIParkngDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e7296171b50a3011b46c896310193f89">
                  <SHORT-NAME>AIParkngEPAMdsts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngEPAMdsts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1062476fee5d36fcb09c95d9685671ef">
                  <SHORT-NAME>AIParkngRespICB</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngRespICB</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e20e3616464f3abeab289a0e75c360c2">
                  <SHORT-NAME>AIParkngSSPLotSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSSPLotSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="239b4fe8e2043c54a1a9da5b23860e89">
                  <SHORT-NAME>AIParkngSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f8f79a3e9e1c39269ce62c3bdfbb31d4">
                  <SHORT-NAME>AIPilotIntervQuit</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIPilotIntervQuit</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="174e4ca5eac9334ea7debc44cfdbc77e">
                  <SHORT-NAME>APAParkInOffsetType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAParkInOffsetType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9ed3712c0c393f1a9272ba0081fd0547">
                  <SHORT-NAME>APARemShifGear</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APARemShifGear</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f5ef7bf98d7e3cec95f4d9645aa180f1">
                  <SHORT-NAME>APASW</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASW</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="716a1d926e043329befb18d292d08df9">
                  <SHORT-NAME>APASpdMdSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASpdMdSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0c92ca9691613dafae46647778360307">
                  <SHORT-NAME>AutoMainBeamLghtReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoMainBeamLghtReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0d5058d57d06307fb2529b363d279909">
                  <SHORT-NAME>CCSpdVcCmdCnfm</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCSpdVcCmdCnfm</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="07650d8cb6f13ccca2eb2e6594f47e22">
                  <SHORT-NAME>CCSpdlVcCmdSwReqDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCSpdlVcCmdSwReqDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eb7594ca0a0d3d6bbfe9d95e149a8a4a">
                  <SHORT-NAME>CSFStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CSFStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2dec6e4d4e03350495d0bc8ad6ee4838">
                  <SHORT-NAME>D2DPriETClanSwReqResps</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DPriETClanSwReqResps</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc1c519bb3813c9f9ae853fdf59e01b4">
                  <SHORT-NAME>D2DSwReqResps</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSwReqResps</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4aaaaceb2cc5327b8beb67ff9a347861">
                  <SHORT-NAME>D2DSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d3aa99c79a5f3243bd7f414f489e5f7e">
                  <SHORT-NAME>DTCInfomationIPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DTCInfomationIPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a9ca07a183da310ea7d0bee0baff82a3">
                  <SHORT-NAME>DetourMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DetourMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="28282db499313effa5ebde39fc188009">
                  <SHORT-NAME>DistSinceTrgtCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DistSinceTrgtCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bd6053e8792c36b6a6515388b29e8db0">
                  <SHORT-NAME>ELKDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="22f714ae122c36219a1491dc7e14267e">
                  <SHORT-NAME>ELKSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="04f67386b5dd39a8af1c9373070e25c4">
                  <SHORT-NAME>ELKWarning</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKWarning</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a22b0b09d3c63a1286c82cd68a7cb79b">
                  <SHORT-NAME>EORWarningEvtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EORWarningEvtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4f549c287f09351a8ae13520aa13d6f1">
                  <SHORT-NAME>ESFStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESFStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b6e2124ec5043457b681aac9ce35a769">
                  <SHORT-NAME>ESSAdoWrnngDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSAdoWrnngDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="30ed423698e1338d8397f3317add7e8f">
                  <SHORT-NAME>ESSDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1535cc271d073217901d48a5357e2165">
                  <SHORT-NAME>EvtPotclSigIPD1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7a33c7b3cf4a3d9f87ba49d914edbee7">
                  <SHORT-NAME>EvtPotclSigIPD2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="99cef02b349f3749bdbb19e0c92ff422">
                  <SHORT-NAME>EvtPotclSigIPD3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ea67bb5dcd4934dbb2fc99a3f9189130">
                  <SHORT-NAME>EvtPotclSigIPD4</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD4</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d1828923de3632faaf5abf7d9fd47553">
                  <SHORT-NAME>EvtPotclSigIPD5</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD5</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4de56795ee2431099a876b0c3da334ce">
                  <SHORT-NAME>EvtPotclSigIPD6</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD6</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="db3278a894e73624aec5c2d092b4a99b">
                  <SHORT-NAME>EvtPotclSigIPD7</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD7</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="054caba7fa143b04af8481177f2cb49e">
                  <SHORT-NAME>EvtPotclSigIPD8</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EvtPotclSigIPD8</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8508b20ee09a37eeb38de289a49ea6a1">
                  <SHORT-NAME>FCTBSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="aaaac67fbdd637c5b4a7628635612385">
                  <SHORT-NAME>FCTSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0e56a64ca64532d9b34fd33aa2161383">
                  <SHORT-NAME>FCTSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4e4bd18536d63f689bbc85354fb819cc">
                  <SHORT-NAME>FCWDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="daadd42b80ac369698e21cf2a79f5e22">
                  <SHORT-NAME>FCWSnstvtLvl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cddd9fa7c72a300ea75074c5495bd922">
                  <SHORT-NAME>FCWSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f39d6027257438acb86f5044ce885fdd">
                  <SHORT-NAME>FCWrnngSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWrnngSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="56a5423ac5d8328c9632b93ce81bce00">
                  <SHORT-NAME>FLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a0b5ef68b2c3e7d92e77bc4a3d1eaff">
                  <SHORT-NAME>FLSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f02f617dfff939a99bce9feb63c8370d">
                  <SHORT-NAME>FLSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="393a726e07b53f7c92d39ddd4d2b0550">
                  <SHORT-NAME>FLSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4f924325a338383a961d4d5edbe1de50">
                  <SHORT-NAME>FLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="27466ca8bd6b3dc3a8fd4c665f5d5771">
                  <SHORT-NAME>FMLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01c89a7532fc35df9bfdcc2e2e1ff5e1">
                  <SHORT-NAME>FMRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="154699e7b0fa3bc0a0a51af486c21dd8">
                  <SHORT-NAME>FRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f267c27a0b143d448e5f291d77a44722">
                  <SHORT-NAME>FRSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fa96ab12aa723cdaa70803da689237db">
                  <SHORT-NAME>FRSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a095e7567f953eeeaa5f8e6cf3f98ca8">
                  <SHORT-NAME>FRSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a4be12c0140e3aa09e1bff64d3eb4805">
                  <SHORT-NAME>FRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="332436beefa0324eb531c65680d0de41">
                  <SHORT-NAME>FVCM_10ms_Group01</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0eaaf5fdafc7305d9e7578cd83d4da84">
                  <SHORT-NAME>FVCM_20ms_Group02</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FVCM_20ms_Group02</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7bc40d92f3553cd08111dd81eea4ef57">
                  <SHORT-NAME>FrtCamrHeatCtrl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatCtrl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="37be6de97dab3153b9ceea8520a27bbc">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7835e83699ee30b4a1e721f6076ce155">
                  <SHORT-NAME>FrtMidLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f9795c7d45bc3fe79745ad74854099f1">
                  <SHORT-NAME>FrtMidRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e6a1faea318736a0853c7d31d18bc9df">
                  <SHORT-NAME>FrtObsDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7c074f4094cf3307ad385d98387ff2a3">
                  <SHORT-NAME>FrtPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="47100e801b16387399069a8374f2a196">
                  <SHORT-NAME>HORWarningEvtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HORWarningEvtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e2b2c5ec465234f496e9e0eafa69fe31">
                  <SHORT-NAME>HPPFnSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPFnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="920b8ddc5da73ed9be08c7f35656bdff">
                  <SHORT-NAME>HPPInBmtSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPInBmtSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1de5ca64e8843133a3e483e8068d6725">
                  <SHORT-NAME>HPPMapBuildSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPMapBuildSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4ef60fa8b3b3377bba36b5b8d868646b">
                  <SHORT-NAME>HPPOnRoutSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HPPOnRoutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e16c0c365cf63bb3b9d2d754eb52bcd9">
                  <SHORT-NAME>IACCOvTSuppresCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7aaab448c3eb3b07b109486aa438c0eb">
                  <SHORT-NAME>IACCPreMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6f75151ff278329eb1cf28d93b002645">
                  <SHORT-NAME>IACCPreSpdLimtCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4a891134da053b648c32254f06d29ed4">
                  <SHORT-NAME>ICBAD_100ms_Group25</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group25</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5b554fd22dbc3360946536d4d8441294">
                  <SHORT-NAME>ICBAD_100ms_Group37</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_100ms_Group37</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="607c7753295330eeb327e89f15840dea">
                  <SHORT-NAME>ICBAD_10ms_Group01</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_10ms_Group01</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b261452295bb3e189c1992c9bb2bbbfe">
                  <SHORT-NAME>ICBAD_20ms_Group05</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group05</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a95f6950dd333382a40796fd5b1264c5">
                  <SHORT-NAME>ICBAD_20ms_Group07</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group07</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bbd5ebfbe01c3864a661ad313068f5e5">
                  <SHORT-NAME>ICBAD_20ms_Group09</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group09</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b4b42c0109123c5e94d1595b37867e06">
                  <SHORT-NAME>ICBAD_20ms_Group12</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group12</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8df134bc723d3e00a9ca7091db3629ec">
                  <SHORT-NAME>ICBAD_20ms_Group13</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="507b5cbe42423e13b9e342343813305f">
                  <SHORT-NAME>ICBAD_20ms_Group15</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group15</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3deac4b098c63b4db25c71d440aad4c1">
                  <SHORT-NAME>ICBAD_20ms_Group46</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group46</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d53901df7143394688c63c3894a68919">
                  <SHORT-NAME>ICBAD_20ms_Group48</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_20ms_Group48</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a5e3a056df6637239a4942258ef5004e">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_10ms_Group20</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="84fc1d3ae47e3a9a9fe6cb9609f94221">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBAD_ZONE_20ms_Group13</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e24ce7f686bf3285bacd1bdf41cdbda7">
                  <SHORT-NAME>IPDAVCamrHeatReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAVCamrHeatReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a84ad8f9699934abbd056febd99a359a">
                  <SHORT-NAME>IPDAlgFlag</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAlgFlag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ae7a931a683c3b488f4a14cac915cb9c">
                  <SHORT-NAME>IPDAurixTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDAurixTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4b3e40df24d33c35b7b032c9062e6abd">
                  <SHORT-NAME>IPDComKeyEnbResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDComKeyEnbResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="885197f0655132f98884fa7df09f6f7e">
                  <SHORT-NAME>IPDDataId</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDDataId</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5e505cd846b43c59aadef5e193f99e42">
                  <SHORT-NAME>IPDErrorCount</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDErrorCount</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c9d77d68205b3418ad9da2769e381492">
                  <SHORT-NAME>IPDFailedReason</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDFailedReason</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e5945d7a7c3e3f61aa47f4d1beb646d8">
                  <SHORT-NAME>IPDIdentityResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDIdentityResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2efd36bac1cd3aeca05bcff76eab43b0">
                  <SHORT-NAME>IPDKeyStatus</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDKeyStatus</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="104f4691f1213e259640c04988b17dd1">
                  <SHORT-NAME>IPDMCUTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDMCUTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eb9d716d6cc23f30aec3b06d018aeef2">
                  <SHORT-NAME>IPDPCBTemp1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc4b7688fd013b57a882051dc295e164">
                  <SHORT-NAME>IPDPCBTemp2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPCBTemp2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7e42abc1008e344993dc2b7da726961d">
                  <SHORT-NAME>IPDPMICTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPMICTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9940211f0ec232b89dbf68765bdf9c14">
                  <SHORT-NAME>IPDResetCnt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDResetCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bdf0617a8c593ae5a60c2ca18430099c">
                  <SHORT-NAME>IPDSOCTemp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDSOCTemp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7f2a9b01fc463492ba1e7c0653eeba88">
                  <SHORT-NAME>IPDStsResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDStsResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="789b6c03ed143c1e86a26c46e0d34a5a">
                  <SHORT-NAME>IPDThermalWrnngLvl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDThermalWrnngLvl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b18818da86b038b683472f6f1f77d92f">
                  <SHORT-NAME>IPDTripCnt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCnt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e80d099bae2e3182ac13cff94d5b8a41">
                  <SHORT-NAME>IPDTripCntResetResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripCntResetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dd84ef06249a369fadce1a363b28aab0">
                  <SHORT-NAME>IPDTripNvmTag</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDTripNvmTag</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3e8b027a42513497bd6f0e6e49ad49ca">
                  <SHORT-NAME>IPDWtrClntInltFlwReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltFlwReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e7d61ca36b9e340583c1de75b008aec8">
                  <SHORT-NAME>IPDWtrClntInltReqFlg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltReqFlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b2d5f63e499835ec83406fd687a04839">
                  <SHORT-NAME>IPDWtrClntInltTimeReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDWtrClntInltTimeReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f16f16d44b933a0e8d02ccf21acaa482">
                  <SHORT-NAME>IPD_20ms_Group43</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group43</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7a43ee5a15c83de5ab3f371060bbe380">
                  <SHORT-NAME>IPD_20ms_Group60</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group60</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c32c8cadf0cf3d6da9bcd6f0783bf6b5">
                  <SHORT-NAME>IPD_20ms_Group64</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group64</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="134d469f581631378c59ab0129609a6f">
                  <SHORT-NAME>IPD_20ms_Group67</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_20ms_Group67</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c280dde1a901309cab67a41e1896f231">
                  <SHORT-NAME>IPD_50ms_Group14</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group14</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7db29b9b8db03744809fe3aeff921001">
                  <SHORT-NAME>IPD_50ms_Group49</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_50ms_Group49</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8581001112c33810aeb96d47c47ceff4">
                  <SHORT-NAME>IPD_NKI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="aad767097fb237a0809285e2c3d89a85">
                  <SHORT-NAME>IPD_NKI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b271c597de583bd8a9f1e0b637a4b069">
                  <SHORT-NAME>IPD_NKI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4f5b52ad356a3a068f523c3f19ef9dcf">
                  <SHORT-NAME>IPD_NKI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NKI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f5e8827f12a83af0bd8633fd721dc567">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c663344c9f18385ba3e2f708e9562a75">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b3e351d1644b324f823a3ebc2b60e790">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8f540bca39283b09b68df2532bf04e78">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e4959e6b05453151a86ca802b26e966c">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0b3ccda7e1f535fab4a271143ff77e56">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b3405d09b989336b80c794c94de2828a">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c42b07aedcbf3af68f8b956bd60ce047">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a27f2f7bf1b83b6bbae09af0338cda6a">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dc9b6b1bc73835fba3423098d16ea43d">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e493f8e72b7c3661ac18755c5c506c2f">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="deee5906e3533793b9966a9dfad1cafa">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_NOStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c605d6312bc7319d94d380ed6561bca1">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a23fc7ad7435324692b40bf0415b41bd">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a8cce50d669f36869465d3345d47c367">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bde8fbe06f4e31d18786c152662864ff">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_PBSMtoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d5ad9a4285053938aa101c218a8ca619">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4a4c3b8749cc3455bf82600232d1c398">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5366d1cd78ff3602b2e7dc85727d8106">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01249f9ce91235dfb82a1defb2758ebc">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMSSta_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d2ec2848d62430a4b55a23f4d70216c7">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d49be22dd71332edb0c8ce3c855f5020">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5dc6a15c39b632a8805f98f4e3723225">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dab0bdcd0c3f302ebf9f9f5fbe6a0c85">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RMStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e82dd05fe3ee3762ba8baebe4d050f40">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="25ef95042b5733298871b3f4c7b23c4d">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1e0bf2a4293f3c53b8144309a0dfa5c8">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="920b889e390a3cb1bf5264a8295f7286">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoNOS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3bf5cf7969f53a2885c455c00d56956c">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5e06ee72c15334a7a9cca887b0aa0a91">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3f88cb0ac6f039a4ba31c9a46b243603">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="96902ae8f60d34b08f1f9aa719ab3849">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NM_RSStoRMS_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1568f2c084f135c9921953119b59223a">
                  <SHORT-NAME>IPD_NOI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1b070a9289c0364493d859fdc779c049">
                  <SHORT-NAME>IPD_NOI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4d6bf14b4df231a884ddb85ea63a3274">
                  <SHORT-NAME>IPD_NOI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="50223cd38910307d9ac59f0bc63928f5">
                  <SHORT-NAME>IPD_NOI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NOI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3790adaf0027300f9bbe998c42ca1e5e">
                  <SHORT-NAME>IPD_NWI_BKPCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_BKPCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="28705318efda3ffe9a4eb39545673a5f">
                  <SHORT-NAME>IPD_NWI_CHCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_CHCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="95417f14d63234d6914615ceea7e162c">
                  <SHORT-NAME>IPD_NWI_PTCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_PTCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a79e4435716d3642952ce73a9f6b8c11">
                  <SHORT-NAME>IPD_NWI_SFCANFD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_NWI_SFCANFD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="62a63a08bdbf38cc8fa13a1ed796fed9">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_Sporadic_TimeSync_Group</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6ef31e2fc13533749ec05d89978955b2">
                  <SHORT-NAME>IPD_VehLckCtrlReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPD_VehLckCtrlReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1b2702c6c51939e3a708eae2f4d5e87d">
                  <SHORT-NAME>JAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/JAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ec2dd1dacc603dedb45886e73910b9d5">
                  <SHORT-NAME>LADSCurToEndPntDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSCurToEndPntDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="26b4639ac25c3a2cad535176bd271938">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LADSInfoDispReqToICM_HPP</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ed4fcbd7a99634bd89fd9d374b42d1e4">
                  <SHORT-NAME>LCRInHMI</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRInHMI</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7defb953fec032daa51f9d6bb30095f6">
                  <SHORT-NAME>LCRSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="49c2e9b5d02b38c486a110c85d09cb9b">
                  <SHORT-NAME>LDWStsForEdr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWStsForEdr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="264cfd85178f3db0a9563f04b701cad8">
                  <SHORT-NAME>LFCTWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6fdf46d1c5973b7c97f8ee6ef3912240">
                  <SHORT-NAME>Lane0_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dc356bc68199350da402cf3eb615daf4">
                  <SHORT-NAME>Lane0_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a14f72a174ce3f3bb304c330151d72d7">
                  <SHORT-NAME>Lane0_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1fe9f65e2509365cb329fde0c446ccdb">
                  <SHORT-NAME>Lane0_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f681898cf09839349bc44a29309fe75a">
                  <SHORT-NAME>Lane0_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0df7962a183b3414b886fdb437cd05cd">
                  <SHORT-NAME>Lane0_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b4fc09462f663668a564717934a6c9c7">
                  <SHORT-NAME>Lane0_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ea3062c4a96a32f69d72f21e3b602968">
                  <SHORT-NAME>Lane0_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9e78dfc9352035d3b024eb3228d56a4d">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1db8f27dd43c30c083d89e74ab869a23">
                  <SHORT-NAME>Lane0_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6ab9c3f7230e3319bcef91db2a20aec7">
                  <SHORT-NAME>Lane0_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ebafe54dfcec326bae2716c66b5ac29c">
                  <SHORT-NAME>Lane0_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane0_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d042792ca15d30e987dd67b276c56d4f">
                  <SHORT-NAME>Lane1_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e30c05f2b11030a49ae7c5be0dbc4e3e">
                  <SHORT-NAME>Lane1_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="df3630c6a4f435c190a1500a32ad40f9">
                  <SHORT-NAME>Lane1_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7512adf53c823aa2b0948ce21f2c4880">
                  <SHORT-NAME>Lane1_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="272d627810de36aa84428393d38ef77c">
                  <SHORT-NAME>Lane1_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d92ddd7a225e387097775f4f7e86deb0">
                  <SHORT-NAME>Lane1_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01ac54222fef3d748ccc86070da0afb7">
                  <SHORT-NAME>Lane1_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="59c7143080fc3026b1dd072e9942e354">
                  <SHORT-NAME>Lane1_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b7b9498c6d0835f591c89168dff7eca0">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6ee4f343b6dc382d856e8b221c6057a7">
                  <SHORT-NAME>Lane1_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="690b29d4ce7635b3bb53ead767b34a1a">
                  <SHORT-NAME>Lane1_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c90f33417b0b3b8a844c9180112ef38e">
                  <SHORT-NAME>Lane1_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane1_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="24729246e76d36a3bdee4c5630aa54cb">
                  <SHORT-NAME>Lane2_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bcb39db332fa3f0584fe00b0825611e1">
                  <SHORT-NAME>Lane2_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="43fe27c8fb9034e8aebfe25593cba3b7">
                  <SHORT-NAME>Lane2_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f4df985259f33134ad384f1b0ac80db5">
                  <SHORT-NAME>Lane2_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ec28bc41aca8329fb3b59459ea9e4d39">
                  <SHORT-NAME>Lane2_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="19a3273c016d35c1b184c23a1d35e134">
                  <SHORT-NAME>Lane2_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5ed4aa00bc4c36339ec9dee90821eeb5">
                  <SHORT-NAME>Lane2_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8bd8c56bc46b3079940794f516c2f7d3">
                  <SHORT-NAME>Lane2_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1fe911f3735c3b74a0e3ad2067f856ad">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="154f3b39360f3383b393631d92ab5fb7">
                  <SHORT-NAME>Lane2_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="707f7f5bf28532a09b79121c4489f377">
                  <SHORT-NAME>Lane2_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="33dbb91c6a9e32dda711d0b89afe5046">
                  <SHORT-NAME>Lane2_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane2_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ae7c0378ba5b3bbdaae4df31bc1142f2">
                  <SHORT-NAME>Lane3_C0</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C0</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4008bbc6d0c431caadd8a4b3eb6746f5">
                  <SHORT-NAME>Lane3_C1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="12f427e360e23625b0fed71014cc8598">
                  <SHORT-NAME>Lane3_C2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3537913d1abd3179886c3a80a889e3c9">
                  <SHORT-NAME>Lane3_C3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_C3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="457eb9035e533f7f8d15765feab4e616">
                  <SHORT-NAME>Lane3_ExistPrblty</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ExistPrblty</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5f357705edde365aacc4a9739c93b55d">
                  <SHORT-NAME>Lane3_ID</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ID</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9c6b6998ef353451877a941ea843b601">
                  <SHORT-NAME>Lane3_MarkerColor</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerColor</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8f16d6d6e076317eb80d5f4498056178">
                  <SHORT-NAME>Lane3_MarkerType</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_MarkerType</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4216001d75a43db8bbf8fae487d39fea">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_Part0_SyncFrameIndex</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="734ec9091fd63249a2de33bf8619dd5e">
                  <SHORT-NAME>Lane3_ViewRangeEnd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeEnd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="29355c5d1fb9373691ba941fc3871279">
                  <SHORT-NAME>Lane3_ViewRangeStart</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_ViewRangeStart</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="628fd3cd65f131a994aeef7600dde481">
                  <SHORT-NAME>Lane3_location</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/Lane3_location</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="813eac953ef438d280206a929d9f50c6">
                  <SHORT-NAME>MemParkngBtnRcnm</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/MemParkngBtnRcnm</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="46fc2567d95f354681f217f2d47f9a21">
                  <SHORT-NAME>NOACitySysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOACitySysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c3fcaf4f75e137d1a05c2b4edf0285e6">
                  <SHORT-NAME>NOADistDecMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOADistDecMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="68ecff91ccda3842861697bc655b3c0a">
                  <SHORT-NAME>NOAETCSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAETCSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d2e8a8b45c393fa4abcedabe21605189">
                  <SHORT-NAME>NOALaneSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOALaneSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ec52438ce4583e91b5d711aa53e06c58">
                  <SHORT-NAME>NOAQukChgSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAQukChgSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bdfb24abe7c538aa9d6520b07aba6743">
                  <SHORT-NAME>NOAReportSetDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOAReportSetDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="058c67a9877c3b049d68fdf40821cc95">
                  <SHORT-NAME>NOPCitySwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPCitySwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fd7b288aa67d3a5e867e86c881984f3e">
                  <SHORT-NAME>NOPSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6d0f5fdea5323e64be8eb1fbbc3c9153">
                  <SHORT-NAME>NOPSysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NOPSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="216bfdf7395137aca3ba71974886fe22">
                  <SHORT-NAME>NarRoVslAssSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarRoVslAssSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="721cda0b36973663a1bf030f5e6d36c4">
                  <SHORT-NAME>NarrowRoadBackwardSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadBackwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="66e5c5fdd4733af3ad83bf7aa3ad5717">
                  <SHORT-NAME>NarrowRoadForwardSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarrowRoadForwardSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d77f0650da01355587d6bb1e3b85ac64">
                  <SHORT-NAME>NarwSpcAstBtnSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstBtnSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ed933fb9425533e1aa6041891b2684ca">
                  <SHORT-NAME>NarwSpcAstSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NarwSpcAstSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="083766651eaf39a498493dec0ff9d5da">
                  <SHORT-NAME>NonDirectDMSSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="04a9d3748c12398c97fbbf88c6da0a2a">
                  <SHORT-NAME>NonDirectDMSSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NonDirectDMSSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cb9d5cc1143f31de8027ff317e7009d0">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssConfrmSwDscmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="1804bcce82373803a3ca6face40b1fcd">
                  <SHORT-NAME>NrwroadBwdAssMesg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssMesg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a8a24644208f35769bd22a7b8fa1fb34">
                  <SHORT-NAME>NrwroadBwdAssSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadBwdAssSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f7374dfdbfe43c519bad0a255122a1c1">
                  <SHORT-NAME>NrwroadFwdBtnDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0df59054999c34f396083c76009c0846">
                  <SHORT-NAME>NrwroadFwdCndNotSt</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdCndNotSt</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="593a0fea126e3399b8c6d18768148728">
                  <SHORT-NAME>NrwroadFwdDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="09d1687f6eb03615b2e9ea56f9fe02f7">
                  <SHORT-NAME>NrwroadFwdDst360Req</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDst360Req</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ecbfb3311ffa38fe94f3698cc46d0043">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstBtnDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="82d1337ab413393c9b7a977869aa3e76">
                  <SHORT-NAME>NrwroadFwdDstL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b578012b16083162ac5c51dc23f26237">
                  <SHORT-NAME>NrwroadFwdDstR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e62b2187ea3d37469ec7207533c0d284">
                  <SHORT-NAME>NrwroadFwdDstTostDsp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdDstTostDsp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ef0bc69032da3e3dbd5f0405f9e0ec56">
                  <SHORT-NAME>NrwroadFwdReDst</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdReDst</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="397b11e3cec23bcf9c324b336d599fe5">
                  <SHORT-NAME>NrwroadFwdSta</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="974ede5a33e53f84b2799620f8b386ec">
                  <SHORT-NAME>NrwroadFwdSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadFwdSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4994128d347937b2b72761db51e6c543">
                  <SHORT-NAME>NrwroadsltSta</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/NrwroadsltSta</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="db36bea59f8333259aecebfe54ddecb0">
                  <SHORT-NAME>PDCSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDCSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="18ce6b8c9eda3842b7062a6d7a20328f">
                  <SHORT-NAME>PDSysKeyPsAvlbl</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PDSysKeyPsAvlbl</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4564e9bea53b3dae8baf555a7f7af2a6">
                  <SHORT-NAME>PEBSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ad11dc099a5a3f818cdee81fdacdbf22">
                  <SHORT-NAME>PEBSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d4a888ca85b437f2911681e2d87dd9c4">
                  <SHORT-NAME>PEBWarngReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PEBWarngReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c3f868aa19353401842e562902ceea1c">
                  <SHORT-NAME>ParkngDirAvlSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b80cbf834b2d39c098b67ad60db3d09b">
                  <SHORT-NAME>ParkngDirSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngDirSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3f50b186de1539479781b6d54c376d07">
                  <SHORT-NAME>ParkngEndDis</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngEndDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="08f98d6e99d83943b7792c1f2adf3ae5">
                  <SHORT-NAME>ParkngInPrgs</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngInPrgs</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2cc92216fcd337e4b3e00632fe877861">
                  <SHORT-NAME>ParkngNCPAvlSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngNCPAvlSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d20719cebfef3cea9832931a4fb23d59">
                  <SHORT-NAME>ParkngOutBkCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="155f9608cdda3c8aaaa78725526f17c3">
                  <SHORT-NAME>ParkngOutBkLCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2759f63aeb5e33b6acd6bd2493455157">
                  <SHORT-NAME>ParkngOutBkRCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutBkRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="040ad34868dc392b9285fd56d89a58b4">
                  <SHORT-NAME>ParkngOutDircnSelResult</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutDircnSelResult</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e82ea3675c71362aa64c41fdd2fa8b28">
                  <SHORT-NAME>ParkngOutFLCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8bd29a2528733b95824f06c1b165b810">
                  <SHORT-NAME>ParkngOutFLParllSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFLParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="76a9b787d4fa3c51a08dcd675ac0570b">
                  <SHORT-NAME>ParkngOutFRCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="dea091c43f873550a4f8cc9723935fde">
                  <SHORT-NAME>ParkngOutFRParllSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFRParllSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e2fd203799ba37c08f9eef8685da61ae">
                  <SHORT-NAME>ParkngOutFrtCrsSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngOutFrtCrsSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c02ada37ff0390583207bc79cdf10e3">
                  <SHORT-NAME>ParkngSlotFindSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSlotFindSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fffa2c7ad8903588b82e230e14a69fa8">
                  <SHORT-NAME>ParkngSpdSwResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ParkngSpdSwResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2b921671ce8d3d3988b27c652b7b76e2">
                  <SHORT-NAME>PilotSysADASFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysADASFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a51c9a28f48d3bdfbb0ebd32234030c8">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF1FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9ba06beb6558320294ee53dad8c91419">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrF3FltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2bb48ac9b92638ea8a511c4df1d804dd">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e088bf49e53836a58470d1ccf0f668ef">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrFRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c647ad0664c03e2e8f3e32c926c02f1a">
                  <SHORT-NAME>PilotSysAVCamrRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c3051b65818f3c3bbeab06f4ce7ea71b">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRLSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fc7bd52389ed31a6b0c7a25389e18942">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysAVCamrRRSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5b2c7d3b540736ed92ad38561a45763b">
                  <SHORT-NAME>PilotSysFDRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFDRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7112d2960d5437c29c12694f72737b92">
                  <SHORT-NAME>PilotSysFLIDARFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysFLIDARFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="18a100816ae1325685c9f5cf130d7562">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrFFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2fa1fdfe5e223917881de94dbbb419d8">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrLHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7e0a56f2460633bc944b90e4467c053f">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5d41cb386071351e8384945a30c24278">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysHDAVMCamrRHFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2dc66bb031be38d491ce0e22e9162365">
                  <SHORT-NAME>PilotSysLFSDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e2e1d10b1c4a344ba32a9aa3c871a8c0">
                  <SHORT-NAME>PilotSysLHRDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysLHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8f94b0b97e2431bdb35df6bfe2c212db">
                  <SHORT-NAME>PilotSysMsg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysMsg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="340771c0f730324aa530560ac030c907">
                  <SHORT-NAME>PilotSysRFSDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRFSDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="f36d7cc98afe32adbbcb7ea1a303e9b4">
                  <SHORT-NAME>PilotSysRHRDAFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysRHRDAFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c8913d06354e364d9d5a257e3a18f054">
                  <SHORT-NAME>PilotSysUSSFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PilotSysUSSFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="189a0b3427d93f3e8240f9b6ec49365a">
                  <SHORT-NAME>PosALCFailed</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PosALCFailed</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6a7f0bc6830d30ffb2c57a9cf32d07aa">
                  <SHORT-NAME>PrvOutSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/PrvOutSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="78771414d3613ff48ccc1f14eb04a879">
                  <SHORT-NAME>RAAlrWorDis</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RAAlrWorDis</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="944052cdae863598b0784acea3a39211">
                  <SHORT-NAME>RADSSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RADSSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc0e256eafbf3c2aa1ddeb3725941521">
                  <SHORT-NAME>RASysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RASysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8efe62c8d0fa3320b94a0e9e96197810">
                  <SHORT-NAME>RFCTWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RFCTWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3fa12d3b14bc3bbab49b9e678bcca7e0">
                  <SHORT-NAME>RLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b40a8c82785f36fabc5196e19b374920">
                  <SHORT-NAME>RLSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9cc7b2f1cf57317584c2e16cd4961b1e">
                  <SHORT-NAME>RLSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b50f35ecf8723c6f83a350320f8dfd5d">
                  <SHORT-NAME>RLSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="05f12a547dc6325c9513641273950419">
                  <SHORT-NAME>RLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9f78b2ad25673fe19d2e0972dbb0df40">
                  <SHORT-NAME>RMLUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMLUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="05dced60788f3891b1f2497dfd05bfbb">
                  <SHORT-NAME>RMRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RMRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e71474756e2b3e7c89a5765c84f55e89">
                  <SHORT-NAME>RPShockDistL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="102084dededc307dbaafc3e823cf172b">
                  <SHORT-NAME>RPShockDistR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RPShockDistR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="619ac55c2fe33ff180784846235c1910">
                  <SHORT-NAME>RRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="183266ac586a336299989fcc1115ea12">
                  <SHORT-NAME>RRSObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="fe387f4c6d84307fb4f8d4f802861175">
                  <SHORT-NAME>RRSUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6d14ffeae103304eb8b15786826d1e92">
                  <SHORT-NAME>RRSideObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRSideObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="abac0c6eb1df383aba92c5c123e7a03c">
                  <SHORT-NAME>RRUSSSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RRUSSSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d52a8bedf08a3f09b0f5fdae5b0fbe2f">
                  <SHORT-NAME>RoadHeightL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6ab31fa5c11c32cca8ebdbb15e036a1a">
                  <SHORT-NAME>RoadHeightR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8c80cdd69cda384788f718f58a93c166">
                  <SHORT-NAME>RoadProfileShockConfidenceL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5e35dff5685f3f6580db36a83cb8217f">
                  <SHORT-NAME>RoadProfileShockConfidenceL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b0be7c66799131058aafe1c462defbd8">
                  <SHORT-NAME>RoadProfileShockConfidenceL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc49da35e7a83725b60c82c7b9a48963">
                  <SHORT-NAME>RoadProfileShockConfidenceL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="043959cd9f433b89b759904eb43459cf">
                  <SHORT-NAME>RoadProfileShockConfidenceR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a4cf7c5eafbb3b36980cc9f28627f2b8">
                  <SHORT-NAME>RoadProfileShockConfidenceR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="06c66219a312340eb81177098996c986">
                  <SHORT-NAME>RoadProfileShockConfidenceR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5a9eac15e11a397090252da3bc3d73ac">
                  <SHORT-NAME>RoadProfileShockConfidenceR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockConfidenceR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="00442893a7db3be4bf3b5b0f3543fdbc">
                  <SHORT-NAME>RoadProfileShockDetectedL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d85c3dcd178431d693faf0a44eaee96d">
                  <SHORT-NAME>RoadProfileShockDetectedL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="82cc3fe3feb434e3ae0b716dfd86a2af">
                  <SHORT-NAME>RoadProfileShockDetectedL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6a2ca9302ca93c65b47225707729a73d">
                  <SHORT-NAME>RoadProfileShockDetectedL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="01f343ac670f3c1a9cc8dfdde7ebe0ae">
                  <SHORT-NAME>RoadProfileShockDetectedR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="eeb76eece92632aea0e5d32c4c24bc3f">
                  <SHORT-NAME>RoadProfileShockDetectedR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="92015ba4c81936dda67ce04cd11ff013">
                  <SHORT-NAME>RoadProfileShockDetectedR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bb02e141a7d432148b35aeea39088614">
                  <SHORT-NAME>RoadProfileShockDetectedR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDetectedR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="974e9e10f8e13782bad3e8665bd22c61">
                  <SHORT-NAME>RoadProfileShockDistL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5b6027e69c723bfcac7c8f8107201417">
                  <SHORT-NAME>RoadProfileShockDistL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="caf58a9398de34948866a74bf27299f3">
                  <SHORT-NAME>RoadProfileShockDistL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d33b148ecde633758e1ddd1656e295d0">
                  <SHORT-NAME>RoadProfileShockDistR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6037cec8e17e3fdd92027709fa080260">
                  <SHORT-NAME>RoadProfileShockDistR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2bbec459c8603c27b4add3f6858cfc83">
                  <SHORT-NAME>RoadProfileShockDistR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockDistR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="51f84779dc593c4ea372468a7141cf92">
                  <SHORT-NAME>RoadProfileShockHeightL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2cd2bd5e00c838cdbb2efc663af67225">
                  <SHORT-NAME>RoadProfileShockHeightL1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e86744f67b53399b914fb6ab67b75262">
                  <SHORT-NAME>RoadProfileShockHeightL2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d38aef1bcecc34f2adbd7d2f8fe58576">
                  <SHORT-NAME>RoadProfileShockHeightL3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightL3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3f2ad5ff4f3d34779df9532c3a4edb77">
                  <SHORT-NAME>RoadProfileShockHeightR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4a63b3b675cd36d2aa656f3587bb03f5">
                  <SHORT-NAME>RoadProfileShockHeightR1</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR1</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="236cc084a91f321195485187a7a94995">
                  <SHORT-NAME>RoadProfileShockHeightR2</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR2</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7ff8b95c0de23705a984a81326de2811">
                  <SHORT-NAME>RoadProfileShockHeightR3</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockHeightR3</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bcdf06165b2f3f67b495647111168d04">
                  <SHORT-NAME>RoadProfileShockLevelL</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelL</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="a2d6cb23f8363bfc9a483e3beeb25074">
                  <SHORT-NAME>RoadProfileShockLevelR</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RoadProfileShockLevelR</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="724b6b2880d632a6a47db680872fe6cc">
                  <SHORT-NAME>RrMidLObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidLObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="8804dc5e8edb3461930b6c0ddeb08e49">
                  <SHORT-NAME>RrMidRObsRng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrMidRObsRng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="368cb0e1a57530a8ab6bf935a789a161">
                  <SHORT-NAME>RrObsDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrObsDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bc89b52120ba37a786b2603f8beff8e5">
                  <SHORT-NAME>RrPDCAudWrnng</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/RrPDCAudWrnng</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="98b7cd433ba731e193377e27a1abc45d">
                  <SHORT-NAME>SLIFAudWrnng_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFAudWrnng_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="248823b8f898360b8dda4a50afb02e7b">
                  <SHORT-NAME>SLIFSts_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="3749efe6b2c533c2b9b76e098df78086">
                  <SHORT-NAME>SLIFSysFltSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFSysFltSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="db22166c91e03e808eeb5464131b293d">
                  <SHORT-NAME>SLIFUpdtIndResp_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtIndResp_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="910dde671b853d32b1ea558b9d01ad0f">
                  <SHORT-NAME>SLIFUpdtInd_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFUpdtInd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="53c85596568f3b4eba27b1c084662928">
                  <SHORT-NAME>SLIFWrnngMdResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SLIFWrnngMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d9e2d14423163707b37eaac74a786b97">
                  <SHORT-NAME>SpdAstCndStsCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstCndStsCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ca4aca21c0633e8ead36c6b73967b458">
                  <SHORT-NAME>SpdAstSysTrgtSpd_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdAstSysTrgtSpd_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0508c6392a173c60ad261e3622f1e490">
                  <SHORT-NAME>SpdLimitManualSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLimitManualSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4506260750c83d0893d45e39a22e53f5">
                  <SHORT-NAME>SpdLmtMdMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="ec97ab4ae32e3722b30a566cece84656">
                  <SHORT-NAME>SpdLmtMdResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtMdResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="334f9860f24635c4b8efd12774456ef1">
                  <SHORT-NAME>SpdLmtOfstSetNumResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetNumResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="337fbf196173385e8bddaabd966f0ef3">
                  <SHORT-NAME>SpdLmtOfstSetPercResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetPercResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="54f830ed346131009e668d6130991efe">
                  <SHORT-NAME>SpdLmtOfstSetResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpdLmtOfstSetResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="64687bcf657a3d1ab9414a87b0e594a5">
                  <SHORT-NAME>SpedRegulaModSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/SpedRegulaModSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7e1a3bf868eb39908efe2f28e1df2f8f">
                  <SHORT-NAME>TJAICAMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TJAICAMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="0faa320bc0803110893f61297e011609">
                  <SHORT-NAME>TLRMdSwDspCmd</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMdSwDspCmd</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="bd0aa3363f3b3d2393dd8a879687e573">
                  <SHORT-NAME>TLRMsgReq</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRMsgReq</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="9610c4da2dd933f5a8d246760c3088e5">
                  <SHORT-NAME>TLRSysSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRSysSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4ab2993d96db3a8e9b1b8d3521977c59">
                  <SHORT-NAME>TLRWarning</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TLRWarning</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4156d8fbe0bb3149a7314de175d528a7">
                  <SHORT-NAME>TSRSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="72701671261f3293b70271be9197b173">
                  <SHORT-NAME>TSRSwReqResp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRSwReqResp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="5b45881eb6bb328aac527bc108ad23bb">
                  <SHORT-NAME>TSRTrgtBanSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtBanSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e465585be8a1365bb55857b345855e79">
                  <SHORT-NAME>TSRTrgtWarnSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TSRTrgtWarnSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="6b6f932cbe473de0b7e7f66c44d79fa8">
                  <SHORT-NAME>TgtParkingFavorite</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TgtParkingFavorite</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b4253a85e84f3ff7ab3e8f3ddc67c95d">
                  <SHORT-NAME>ToEPSMsgChlg</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ToEPSMsgChlg</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="c21eb1614e923253896786e99bd21eeb">
                  <SHORT-NAME>TrfGreenLghtActn</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfGreenLghtActn</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="73333926158b30f4aafa05e699cc2971">
                  <SHORT-NAME>TrfcLghtFuctionSwSts</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtFuctionSwSts</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="7e1574e5887c37ed8d3a638d40db54dd">
                  <SHORT-NAME>TrfcLghtStSp</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcLghtStSp</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="d6861aac206f34a9aaf71c6c589eaaef">
                  <SHORT-NAME>TrfcMrgdForbidDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="589a9713550f35798d076080a9358775">
                  <SHORT-NAME>TrfcMrgdForbidSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdForbidSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="2da755aabbfe3e359f0b73c8a2bed102">
                  <SHORT-NAME>TrfcMrgdInfoSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="b642cfd9d12f37d7b8f10092a21706a3">
                  <SHORT-NAME>TrfcMrgdInfoSignDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdInfoSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="e598d373242c3fb39d6d9dc294106121">
                  <SHORT-NAME>TrfcMrgdWrnngSign</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSign</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="cefa06f3ff263f07bd76e66049556a13">
                  <SHORT-NAME>TrfcMrgdWrnngSignDist</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrfcMrgdWrnngSignDist</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="37949cfc869d3f1f9ec25fc3331beff4">
                  <SHORT-NAME>TrgtCndSpdReqCamr</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtCndSpdReqCamr</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <P-PORT-PROTOTYPE UUID="4e2b6852324439b4a46d119ed88421dd">
                  <SHORT-NAME>TrgtSpdSrcSts_IPD</SHORT-NAME>
                  <PROVIDED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/TrgtSpdSrcSts_IPD</PROVIDED-INTERFACE-TREF>
                </P-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2385761075e43019b9647cc4343119d9">
                  <SHORT-NAME>ACCConfmSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCConfmSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0225b4aafd333e32bd1485e5eed7461e">
                  <SHORT-NAME>ACCCurveSpdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCCurveSpdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2fcd69557f5533679a0463af78dc006c">
                  <SHORT-NAME>ACCSpdLimtSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d1c95189473533c1a55e2224fd480c75">
                  <SHORT-NAME>ACCStsSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCStsSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="dc79fa5160f83f079d2b5fb50d8f1bdb">
                  <SHORT-NAME>ACCTJAMdSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ACCTJAMdSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ca18e14b58253dea95220602995b7eef">
                  <SHORT-NAME>ADAudioSWReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ADAudioSWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9213b2b1055136bbac53702e6149ab16">
                  <SHORT-NAME>AEBSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AEBSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3d57406831db3c7d8ba0ff3736aa06dd">
                  <SHORT-NAME>AIParkngEPAMdsw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngEPAMdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="991c06eb249938fab7c74097d048b81f">
                  <SHORT-NAME>AIParkngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e0f0ce4fddf935a6a5ebf48b4b3100a5">
                  <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReqICB</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="31ac859141d13bb2a59441bb356c15ba">
                  <SHORT-NAME>AIParkngReq_ZXD</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngReq_ZXD</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7d1ba065bd53369da38184af6a5d5f10">
                  <SHORT-NAME>AIParkngSSPLotSw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSSPLotSw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a3d186f941413f30b8157adb7371a1cd">
                  <SHORT-NAME>AIParkngSpcID</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpcID</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5cf2b598a96032238af4fae4b16f5452">
                  <SHORT-NAME>AIParkngSpdsw</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AIParkngSpdsw</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="595882d45ed3339ea5c28663b2e55e83">
                  <SHORT-NAME>APAOneKeyParkSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAOneKeyParkSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5eebbf07bc8f394eb7c86b314db6202d">
                  <SHORT-NAME>APAParkInOffsetTypeReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APAParkInOffsetTypeReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1ac2ca3224473fbab3c7269af8e986ba">
                  <SHORT-NAME>APASWReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/APASWReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1bbeb8f6085c34778521a21b10b84994">
                  <SHORT-NAME>AVMDspReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMDspReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6e8f0b2303523397a5f4ed4d76171a52">
                  <SHORT-NAME>AVMSt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVMSt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0a8e6a2eb616327fa23259e3277061b6">
                  <SHORT-NAME>AVPMapRutMgIDtReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AVPMapRutMgIDtReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7dc86ab4b8433d8b84a46fb0e78bc8b9">
                  <SHORT-NAME>AutoLaneChngSetReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSetReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bd154e5a35e831a4a47610b8aba0dd22">
                  <SHORT-NAME>AutoLaneChngSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7ebe4d016a58392d8ca4c52bc9af4172">
                  <SHORT-NAME>AutoLaneChngVcCmd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoLaneChngVcCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b89b6ba0c0d836b6bbe420d577254305">
                  <SHORT-NAME>AutoMainBeamLghtOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/AutoMainBeamLghtOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5b80b1b85e33353e9ef8dea77627d225">
                  <SHORT-NAME>BSDSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BSDSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a265fe1298c136fe8945a575d088abae">
                  <SHORT-NAME>BaseLineLen</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/BaseLineLen</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="93017d014b6737f098a091f0c02869ba">
                  <SHORT-NAME>CANprotocolinternalversion</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CANprotocolinternalversion</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a1c6aab4adae3d98a767cd9524d67d5c">
                  <SHORT-NAME>CCU_100ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f9e196b07d1b3d7ebd4596a0adfeda8a">
                  <SHORT-NAME>CCU_100ms_Group07</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="19cd6351f59e3fcdbb957c0b696565a2">
                  <SHORT-NAME>CCU_100ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/CCU_100ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="543e76e231e134ae9b92c3b5d33a62a6">
                  <SHORT-NAME>ChrgPwrReq_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgPwrReq_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6c1dcb2b7c1d31098fe595174275819a">
                  <SHORT-NAME>ChrgReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ChrgReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9acf90fa72d136d7a67f4b0378848eec">
                  <SHORT-NAME>ClstrDspdVehSpd_mph</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ClstrDspdVehSpd_mph</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9acf567049d53a05af659cdc0eadead8">
                  <SHORT-NAME>ComKeyEnbReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ComKeyEnbReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="75596d1fc52e3d7eb2cacc8b80b2883b">
                  <SHORT-NAME>D2DPriETClanSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DPriETClanSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e16b4b7017d4397683a3d7d64f64f175">
                  <SHORT-NAME>D2DSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/D2DSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f3a8fd50e9283aa497968a449ea7cd4c">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_0</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_0</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5ea89d0f485f3fcfabd21d8936ff110b">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_1</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_1</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f2deb789345a34a7a1755b9a452c5158">
                  <SHORT-NAME>DFC_Current_DisplyBuffer_2</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_2</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="312e5a7d97e230d99f259db96a275ec5">
                  <SHORT-NAME>DMSCameraFps_IMM</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DMSCameraFps_IMM</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6c817769d28f3a89a4eb88e1e0a194b4">
                  <SHORT-NAME>DOWSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DOWSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cfd0d62a1f6b3a06ab23c43bb80182cc">
                  <SHORT-NAME>DfstOnDspCmd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DfstOnDspCmd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="04729134b7483bc7a0978e71abb30a8c">
                  <SHORT-NAME>DiffAgeInfo</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffAgeInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="638a53eb694830e8aa45018bc9d74f17">
                  <SHORT-NAME>DiffDataLinkBroken</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DiffDataLinkBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0fe5adf050e03ac6bdbda1ae759c0a93">
                  <SHORT-NAME>DircnIndLghtMdSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtMdSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7349481f1848351dbb2c39f41284439c">
                  <SHORT-NAME>DircnIndLghtSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DircnIndLghtSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="13fde9196fad399e93d9355d8c9a29cd">
                  <SHORT-NAME>DistToTrfcJamNav</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DistToTrfcJamNav</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="93ce49e52dfe363ca4a5f9774ba40f0b">
                  <SHORT-NAME>DownVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DownVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="71f592d7df1839868b970157177e08d6">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlFilt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e8150ac2b6ef3382afd767ef098788da">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRawCap_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="80425a6eb24d35a8b0863095b35ddd1e">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvTqReqWhlRaw_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="37dffdc1195431848a3fcb0ced5f3718">
                  <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrDstrctnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f027b83c433e351f8fb944d64e16dc94">
                  <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="41ae0197f6793c6ab36026ee0b7ab32e">
                  <SHORT-NAME>DsblICE_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblICE_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="08e62d2268fc38179a44e97b9837b2d8">
                  <SHORT-NAME>DsblISG_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DsblISG_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="341409f162763f7d8e705102742babd3">
                  <SHORT-NAME>DschrgOptMaxPwr</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/DschrgOptMaxPwr</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="926006061de93e9da1728a0af6ea7971">
                  <SHORT-NAME>ECM_010ms_Group00</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_010ms_Group00</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d9bbf27c71af3242961825348dd5b1ca">
                  <SHORT-NAME>ECM_25ms_Group36</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_25ms_Group36</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d0096308f8d939beba049b6df29037b3">
                  <SHORT-NAME>ECM_500ms_group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_500ms_group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="49af63d058863fbcb04474b8f5c005ac">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_020ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af6b292bbb423ef59e95e51e8c876227">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ECM_ZONE_050ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e2af35210317362f9c34f4a90a13fdba">
                  <SHORT-NAME>EDUClntTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f5d57c11caae3b3a9fcee2854deeda58">
                  <SHORT-NAME>EDUClntTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUClntTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ec160983331f32748b6af3aa6f2cbabf">
                  <SHORT-NAME>EDUOilTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="74b53d8d4a373f38b2d080e13c0d58b0">
                  <SHORT-NAME>EDUOilTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EDUOilTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6596b953b5af3a209b6d5379bb50a3f6">
                  <SHORT-NAME>ELKSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ELKSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8813463247fb3a6386bf9ad2a87d8605">
                  <SHORT-NAME>EPSAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="869a29c118203b489ce3463c19d02076">
                  <SHORT-NAME>EPSCTTX</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPSCTTX</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="cc9b991ac1423e9e8a7ce1a9be2f6a79">
                  <SHORT-NAME>EPS_010ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_010ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1e1251a0aec6317dbdc1a4b4a4e55c8a">
                  <SHORT-NAME>EPS_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a9dc73abf9ab3dca8f7665adaa581f97">
                  <SHORT-NAME>EPS_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b567476448f93ff2aeb735e2ce10eb74">
                  <SHORT-NAME>EPS_10ms_Group05</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_10ms_Group05</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fec7c835da083c18b268d5793a99dc52">
                  <SHORT-NAME>EPS_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPS_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fe48834825d53a10b768939c99fdc2c4">
                  <SHORT-NAME>EPTClntPumpSta</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTClntPumpSta</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="afda3c3085013235a4f5932655bc8bb5">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EPTElecWtrPumpActuSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7d3cb831dddc3e7b802aaf8d180c748c">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCBrkRgnPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9f9b52070da133f4b4f4448a98caa216">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1b697d9e92ef323492b0c2301b2421e6">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="33c129f7dfcf394a8c12ac45a93ccce6">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtPeak_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2d923aecd2ee3573909998256a7cafcc">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtWhl_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4857e6b50dfa383db714f6d59dc42f71">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCEmgcyPwrDwn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9b0e9f43c69032a6a2718158ecb5d2f3">
                  <SHORT-NAME>ERCFCOReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCFCOReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="db37a106ee0c3337824582dbc853a6a7">
                  <SHORT-NAME>ERCHVAllwd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVAllwd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3fe6b7edfcaa3ab888c89dbd5e3e72ad">
                  <SHORT-NAME>ERCHVHldReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCHVHldReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="54084f350f2b3308bc8d498ce640c4d6">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxChrgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="46114ec19f713b34ab1e5eed650ab5b4">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ERCMaxDschgPwrLmt_kW</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5a74252c12823d6ea444d4d03f70149b">
                  <SHORT-NAME>ESCLPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESCLPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9a0b9dd12c753c459255242a0f252c8b">
                  <SHORT-NAME>ESSAdoWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="be52acd597613c7caadc3c64948bd62d">
                  <SHORT-NAME>ESS_100ms_Group58</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESS_100ms_Group58</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c7bff43c0c753e70a324e5c0949d9e25">
                  <SHORT-NAME>ESSswReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ESSswReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f637caa0041437c19d59415a2ba0f128">
                  <SHORT-NAME>EVMd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EVMd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="46cf7fc3c39a327b9b9a2a28e046afd5">
                  <SHORT-NAME>EastVelocityRTK</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EastVelocityRTK</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="15a5cce2dfc039e7938f82fbc0750b75">
                  <SHORT-NAME>ElecPwrDistbnScene</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ElecPwrDistbnScene</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="52150c4cfa133d1ebfea04da16697955">
                  <SHORT-NAME>En12VoltStrMotCmddOn</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/En12VoltStrMotCmddOn</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="813d1ce74bf73254a9df7bc811925363">
                  <SHORT-NAME>EngBrkTqMax_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngBrkTqMax_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9ef2b030f8993695b055717c3e08b5b0">
                  <SHORT-NAME>EngFastTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5059a5401d3335219d6805a569a135d7">
                  <SHORT-NAME>EngFastTqTypReq_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFastTqTypReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d2d45d05d759351482263ca8566379cc">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqFstTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="940d76b12c39338a804b9f5b623cc4f1">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngFlexplateTqSlowTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3f1407c8ba643da69e9ae9ce59b26e3e">
                  <SHORT-NAME>EngPhsAng_deg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngPhsAng_deg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="abea46a6c8cb3d1dbd3d4958938c69f2">
                  <SHORT-NAME>EngSlowTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSlowTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7bbe22be24813a178ba1ba9a6aba419c">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngSpdSafe4EngStrt_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="149bbcfeeace3fa489983481f37c4a6c">
                  <SHORT-NAME>EngStallCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStallCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d26fc8f172fb3896820329de42fe83f0">
                  <SHORT-NAME>EngStall_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStall_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c547308aea7b3a0dac08a60a3357c7e3">
                  <SHORT-NAME>EngStopReqCfmd_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStopReqCfmd_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bd43552f6cf032a4acb11d2c991b16bf">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtDampSlipFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="da5590b89c4b3e6ea1990c749a1216b2">
                  <SHORT-NAME>EngStrtFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a5dce7fd737b33538451110176fe4dfe">
                  <SHORT-NAME>EngStrtFail_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtFail_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4a40569f337132b9873b816892f4e849">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtNoCapFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fb3af2c1f29c3596aacd9ea117786fd8">
                  <SHORT-NAME>EngStrtReq_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtReq_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b73a903d6c893e07a582ed8bb2d02ac8">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/EngStrtStuckFailCnt_cnt</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6d78f36134cd34f9a4841680308ee652">
                  <SHORT-NAME>FCTBSysFltSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTBSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="95ab30cb22333725a45283a971bebd2e">
                  <SHORT-NAME>FCTSwSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSwSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0dcde8471d8c3cf0b3bd03b223ae805e">
                  <SHORT-NAME>FCTSysFltSts_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysFltSts_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="535736629b2e3a72a37f4932a58b4f96">
                  <SHORT-NAME>FCTSysSelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCTSysSelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="83245cad5ef3344cb79b9284df2ba67b">
                  <SHORT-NAME>FCWSnstvtLvlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3bb28b7887ca38a0b3a60097e836b566">
                  <SHORT-NAME>FCWSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FCWSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0235016e0ff835cc994300a0f49b896f">
                  <SHORT-NAME>FDRPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDRPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6deb9179fc393cc887c0b0f3b977d2e4">
                  <SHORT-NAME>FDR_100ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FDR_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="821438b38c4d3be6b5758d71bc82ff2c">
                  <SHORT-NAME>FLDircnLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="097e2bab2d7f369c9a66de310c253bb8">
                  <SHORT-NAME>FLDoorHndlPESwtActv</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1ea84339e0773fc6b65f80978c64f70d">
                  <SHORT-NAME>FLDoorOpenSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fa7b2f63eb48331a9e955c83272eba65">
                  <SHORT-NAME>FLTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="9176e8ae14e93f8489f333af7732884a">
                  <SHORT-NAME>FLTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4a33985dd28e31f3ab3311853f5f5d7d">
                  <SHORT-NAME>FLTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f2ee8156ec6d33eeb5f618c2d85f837b">
                  <SHORT-NAME>FLTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f5b04da97cb93212b116ec30d164a71d">
                  <SHORT-NAME>FLTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="56c3a7d97004321ab7bd38be30b5a6c8">
                  <SHORT-NAME>FLiDARPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FLiDARPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5ccb21f81f253ada917427766ead0f96">
                  <SHORT-NAME>FOTAStatus</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatus</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="35d571eda54434329f78791b456fb6ed">
                  <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTAStatusValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f92c76fa558034159ba7c71257d7c88b">
                  <SHORT-NAME>FOTATarget</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATarget</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="528df6d7fa3531e8877df1774415bdec">
                  <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FOTATargetValid</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f9b3633a899e38cfb267cb7755e312fc">
                  <SHORT-NAME>FRDircnLghtSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDircnLghtSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="462a0d6d75a5352096b034d8e16233ac">
                  <SHORT-NAME>FRDoorHndlPESwtActv</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorHndlPESwtActv</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2372c522ce2d3728aeeda023053730bd">
                  <SHORT-NAME>FRDoorOpenSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRDoorOpenSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="af1ec7e4a7ba39258eb4fd6d8fbe892f">
                  <SHORT-NAME>FRTirePrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="912a41df1c2d36aeb5cdfc84c17e0458">
                  <SHORT-NAME>FRTirePrsV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTirePrsV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fdfe364f512237e4af51fc03c2d9b83a">
                  <SHORT-NAME>FRTireSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="11915f957f38355db3caaf2618901007">
                  <SHORT-NAME>FRTireTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="38d5086e8da135d185eb91cca5d9e24c">
                  <SHORT-NAME>FRTireTemV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FRTireTemV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ff14c508f9973c17b07504e32b2d1e66">
                  <SHORT-NAME>FrtCamrHeatSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCamrHeatSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="fbfd02344f3a322188ac1e00d14df6e2">
                  <SHORT-NAME>FrtCarGoNotfrSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtCarGoNotfrSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e683771e2ec03bd8bfc0b492fb5cba00">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtPsngDoorOpenSts_LHZCU</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ca3356eb61ec31e1bda979cda4df404b">
                  <SHORT-NAME>FrtTireStdPrs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtTireStdPrs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f119eecf0e2c342fa99d2ca545c865f4">
                  <SHORT-NAME>FrtWindShldSfcTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSfcTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="315e273442a03e0eb606e2731b85a53a">
                  <SHORT-NAME>FrtWindShldSurndHmdty</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndHmdty</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5f252d1f7ed23ba882dfc7d461bbc489">
                  <SHORT-NAME>FrtWindShldSurndTem</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWindShldSurndTem</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6b3128d95d0a3bc3a8fb8cca211845ee">
                  <SHORT-NAME>FrtWiperSpd</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSpd</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d50533f6752334bda0c75f2b1cd06552">
                  <SHORT-NAME>FrtWiperSwSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FrtWiperSwSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="43ae27946f5030bda5454afebec7675f">
                  <SHORT-NAME>FuCutReq_enum</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FuCutReq_enum</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="aced5e52a22631e79dedc8d44150249d">
                  <SHORT-NAME>FulCutDMFPrdtn_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutDMFPrdtn_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="200c4e6a6a0d3e688cc455b5f7a50ad7">
                  <SHORT-NAME>FulCutEngStall_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutEngStall_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ee18cf607f9d31fbb0bb18a50bb540a5">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/FulCutLosCommWthEMS_flg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="85be0181899f31038edba3c3b4aa3f16">
                  <SHORT-NAME>GNSSAntennasBroken</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasBroken</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="852285dc8fed3dfd828d10d4244da4b1">
                  <SHORT-NAME>GNSSAntennasInfo</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/GNSSAntennasInfo</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="45216bcbccce3690aa6b8d69f05a4131">
                  <SHORT-NAME>HCUSAMTqReq_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HCUSAMTqReq_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f4fa5a8c911a343a81b96ce74b0ffeaa">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/HmdtySnsrHdwrFltPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="210c454cf06f394fb6604c3afb51fd3c">
                  <SHORT-NAME>IACCOvTSuppresSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCOvTSuppresSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f00781403fc631068fd47472b07de6c9">
                  <SHORT-NAME>IACCPreSpdLimtSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IACCPreSpdLimtSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eeafa9701ab437ce85052d0750bfa81c">
                  <SHORT-NAME>IAMAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="516c91beb35c357ea4be9fa12c9c80f7">
                  <SHORT-NAME>IAMReststs</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAMReststs</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="2269dfa25fbc3200b2f9b2d835b08bc0">
                  <SHORT-NAME>IAM_100ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="948871c7c0463a9ba3bf4d26e02470cc">
                  <SHORT-NAME>IAM_100ms_Group18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="8cf6075bdbbc3ecd91ecf40edc570f50">
                  <SHORT-NAME>IAM_100ms_Group56</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_100ms_Group56</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="caf9471dbc6830b288427c26a60d01a8">
                  <SHORT-NAME>IAM_20ms_Group32</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_20ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b8d609992d0439c5afe2edb9f4634dc6">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e578667beba134b5a69b3a82856e35e0">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group34</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="ae9a9e81be2039aca6b1d92000603d04">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group35</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3f1ae7ddc6b33825899a5ea492d618ea">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group40</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5d2ec147cbce398c992865d6c05965b6">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IAM_ZONE_100ms_Group57</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="dc880ce76b393c9cb96670b375e4d0b1">
                  <SHORT-NAME>IBS_100ms_Group15</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_100ms_Group15</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6f153fe3ceb93519bc2fbce0231834ab">
                  <SHORT-NAME>IBS_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="45de5a083226377c8b0c95566e0407ee">
                  <SHORT-NAME>IBS_10ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="42bf84c023013b38bcf8b048587635cd">
                  <SHORT-NAME>IBS_10ms_Group04</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_10ms_Group04</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="eb02bfa638e23088be4980b7cd0044d4">
                  <SHORT-NAME>IBS_20ms_Group07</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group07</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="68ba3cd9d78f39efbbe3cd012c453879">
                  <SHORT-NAME>IBS_20ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c453220e748732bbb2eaa6de17a5d713">
                  <SHORT-NAME>IBS_20ms_Group09</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group09</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="364dab3eb4d639ed922d119fb8addb0c">
                  <SHORT-NAME>IBS_20ms_Group10</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group10</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="14c9988894d3390a876b6a178330ba57">
                  <SHORT-NAME>IBS_20ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f95e561fa19c35a4a419bfe65031ae61">
                  <SHORT-NAME>IBS_20ms_Group12</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group12</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a662771b669b313391c090ef3aee43af">
                  <SHORT-NAME>IBS_20ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_20ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="36c1ab67ac1d38d18e4b8fdf4dc7e577">
                  <SHORT-NAME>IBS_CHAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_CHAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c3c4ce425f623476aa62031511450b7e">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IBS_ZONE_20ms_Group08</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="bd8afafbe7bb3f368ffd046ef9a24908">
                  <SHORT-NAME>ICBVC_100ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="994058d3afc23668b79635080659f531">
                  <SHORT-NAME>ICBVC_100ms_Group19</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group19</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="1cf77aa060333951a05db510c514f800">
                  <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_100ms_Group80</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f9d50a8a53f73d8a947ca56061a75b0e">
                  <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_200ms_Group79</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="13280ad420203ba5bf4c7e7128d80e4a">
                  <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="89a5cc85d276305ca5aacdec777e4018">
                  <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group11</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7bf2a357257933b2801be60835b3b40f">
                  <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group13</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="aec34dd880183fe3a4932b24deca7aaf">
                  <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group158</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c71ce9d494cf3e03b226d867bfaf260d">
                  <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICBVC_50ms_Group256</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="c53a090f08423f859f270971dd6b0d4d">
                  <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrDstcnSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="6e763ea1bb92315896c280768608e134">
                  <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrFtgLvl</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="866dcb7bb78138f6bc87387954c591eb">
                  <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMDrvrPrst</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="22940e773f0b3df3ba6c4c8200b5bde8">
                  <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMEyeOnRoad</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d2baf9559bd137d9b322ecfec3161a80">
                  <SHORT-NAME>ICMSwReq_Reserve16</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve16</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4a44af25893d3d7f97ecdae282baa58d">
                  <SHORT-NAME>ICMSwReq_Reserve17</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve17</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e44fecc8a8153ef1a0d9b02fe7e57d61">
                  <SHORT-NAME>ILCSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ILCSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5243de6dc06c38fe87df73b437d0cdbf">
                  <SHORT-NAME>IMM_50ms_Group02</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMM_50ms_Group02</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e0adb5f54bee3d17bdd22577328680ee">
                  <SHORT-NAME>IMU_SN</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IMU_SN</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="4b4d73b9a78a38f28f8da07c7079215f">
                  <SHORT-NAME>IPDPowerFailSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IPDPowerFailSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="b3f0518bcf0e36fb92df9260ccb53bb2">
                  <SHORT-NAME>ISGMaxTqLmt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMaxTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d349fe25c4603dccad14233cde2ecdd7">
                  <SHORT-NAME>ISGMinTqLmt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGMinTqLmt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5c3e4bd7b9fc373da00e0e27be39567d">
                  <SHORT-NAME>ISGTqTgt_Nm</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/ISGTqTgt_Nm</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="99b51416165c34bebc8f82bd029f5c1e">
                  <SHORT-NAME>IdentityChlg</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IdentityChlg</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="5c7fe967135a39e8b057dd9678332a61">
                  <SHORT-NAME>IgnOffTime</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTime</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="d72af5e81f1c3388937467187538727e">
                  <SHORT-NAME>IgnOffTimeV</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/IgnOffTimeV</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0aef2de68bd0354aa5feb801164767a2">
                  <SHORT-NAME>LCASelReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCASelReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="660d84270eee37d68d9adc26d1e1b3e2">
                  <SHORT-NAME>LCRSwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LCRSwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="61ad510139393115b92b5ad203eec719">
                  <SHORT-NAME>LDWAdoWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWAdoWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="48c991bbd37a3074bebce0e7e754e667">
                  <SHORT-NAME>LDWLKAHptWrnngReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKAHptWrnngReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f309e2ecd4503b9782c9799f5890104c">
                  <SHORT-NAME>LDWLKASwReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWLKASwReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="176557a042ce3496876fcdc5d659ffa2">
                  <SHORT-NAME>LDWSnstvtLvlReq</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LDWSnstvtLvlReq</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="e80e82606226367b9889c3c989151f45">
                  <SHORT-NAME>LFCTWrnng_ADAS</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LFCTWrnng_ADAS</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0a6462c74279389f824896b8c541369b">
                  <SHORT-NAME>LHSWPwrSts</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHSWPwrSts</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="a4d5ab30b2ad3cc69d266bb4f9d8b66d">
                  <SHORT-NAME>LHZCUAvlbly</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCUAvlbly</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="67efb592bd24373f924cc1852a829f30">
                  <SHORT-NAME>LHZCU_100ms_Group30</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_100ms_Group30</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="11d9b430ad0d30c8b2e06e43560166f0">
                  <SHORT-NAME>LHZCU_10ms_Group01</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group01</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="3c8f4f771824379c9af15ab401c7eacb">
                  <SHORT-NAME>LHZCU_10ms_Group32</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_10ms_Group32</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="0b86a51fb334315e918ddffa2f875791">
                  <SHORT-NAME>LHZCU_20ms_Group03</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_20ms_Group03</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="92088fefea9837dc830e0e64c7fd87b1">
                  <SHORT-NAME>LHZCU_400ms_Group18</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_400ms_Group18</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="f4a45f2042803ab880e99ec88addaef7">
                  <SHORT-NAME>LHZCU_50ms_Group06</SHORT-NAME>
                  <REQUIRED-INTERFACE-TREF DEST="SENDER-RECEIVER-INTERFACE">/SoftwareTypes/Interfaces/LHZCU_50ms_Group06</REQUIRED-INTERFACE-TREF>
                </R-PORT-PROTOTYPE>
                <R-PORT-PROTOTYPE UUID="7986ef65d4633937989a30ed3842c1f0">
                  <SHORT-NAME>LHZCU_50ms_Group24</SHORT-NAME>
