                    <I-SIGNAL-PORT UUID="66c966d9bfe637c98e9540b1128ff7c5">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved8_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18ba1b5620a43a43addf4df01fa45197">
                      <SHORT-NAME>ICBAD_10ms_Group01_Reserved9_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="703afdabc0833bdfb930d91770ef1309">
                      <SHORT-NAME>ICBAD_10ms_PDU01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="e835abe795f03e93a4bcae67dfb689e1">
                      <SHORT-NAME>ICBAD_20ms_Group07_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30a6577d18af3c0e8714b1987871ec8f">
                      <SHORT-NAME>ICBAD_20ms_Group07_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9334a1cefde73defb89b9ce7359592c4">
                      <SHORT-NAME>ICBAD_20ms_Group07_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a7d7ead42463aa2a76c18291461363d">
                      <SHORT-NAME>ICBAD_20ms_Group07_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b3631e67934347c9f6cdd8563095eb0">
                      <SHORT-NAME>ICBAD_20ms_Group09_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f15a842cf8fb38e3a73d17c4d54aaf74">
                      <SHORT-NAME>ICBAD_20ms_Group09_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f26ed13e9a2b3a0a86befcb32575ce15">
                      <SHORT-NAME>ICBAD_20ms_Group09_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0713bca7fa0537ac96053d570ccdb610">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="899758239fec39139e05a5f1f7f43fee">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="00584ef440793907b9f2ec4e8231076b">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="066f74ac914230d8b9f85ccb7b7affc7">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4191c243aaa330c7a92323b73a9f0830">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21d89e1c22673d4388af82a0cbff4ecc">
                      <SHORT-NAME>ICBAD_20ms_Group09_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="161594076fb8339796d293d45e922f18">
                      <SHORT-NAME>ICBAD_20ms_Group12_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f6b993b45399382dada8437162403a99">
                      <SHORT-NAME>ICBAD_20ms_Group12_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8d64c3d6c843fb5bf49efbd3e40e219">
                      <SHORT-NAME>ICBAD_20ms_Group12_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af9c0a05e31a34c99bec9cd648f047de">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="529a30e5665b37118c81735912ca55d9">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19350dfa9f7f326a89eb043684ca31ff">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab92869a3a433e12b8c546125251e2a9">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bcd3745d21c63e67b6a0989d6826421c">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be67d329ead2330d8daf572d1f79ab23">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88a0bd4e2562357fb96d0997bbec058d">
                      <SHORT-NAME>ICBAD_20ms_Group13_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef656c75b31036e18df889399a9b8620">
                      <SHORT-NAME>ICBAD_20ms_Group13_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a823ad285bb831619bc157ad23a7605e">
                      <SHORT-NAME>ICBAD_20ms_Group13_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c973c30afd9332be9c3b3c46e6c8ebdc">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c55195e8efb348f8887fbcff442138b">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c2e70128b7f3a0fb775bc86f6c8f370">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c2a81c2e1faf3395b7d78e2f6308e5f6">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d573ba716ae327e8142667a18786e3d">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c3c0e60569cf39d4a54893db189e7827">
                      <SHORT-NAME>ICBAD_20ms_Group46_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fba5e450e91830eabe93bfc008bd0b22">
                      <SHORT-NAME>ICBAD_20ms_Group46_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45ed13ad6fc437ca99f21e0755e8e5f5">
                      <SHORT-NAME>ICBAD_20ms_Group46_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d6eb974382a3528b56fb6511fa301be">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="475b2b0abfb9393ea7127fc98f2e3928">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0f8b2b598683dc0867b7d74940f3a51">
                      <SHORT-NAME>ICBAD_20ms_Group48_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e1abb9e30bc13a91ab665aa09523b0eb">
                      <SHORT-NAME>ICBAD_20ms_Group48_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f6f1ad059f233a4eb6071b40656bcbd7">
                      <SHORT-NAME>ICBAD_20ms_Group48_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f280353ad0f3e0f86706e371531b74e">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc0754fbdc99367faa0ce142841f4771">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5eeebe261bc032a2a0298c492b9f8d54">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94e1fefb125d3623abc702f105cdbf57">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b8a1be4edf43de89fe2a2bfc16b1191">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7964b5ab4bc39029d2aa00714f027a8">
                      <SHORT-NAME>ICBAD_20ms_Group48_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="48153b1626ba3c49856dc0ea1323bd9a">
                      <SHORT-NAME>ICBAD_20ms_PDU07_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5ec3a22ca52d3dd7a3a4260b551aeb08">
                      <SHORT-NAME>ICBAD_20ms_PDU09_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ff31e9e6827639f48bd2606650ccae46">
                      <SHORT-NAME>ICBAD_20ms_PDU12_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="602d1ebd880437269d3bead84231bdcd">
                      <SHORT-NAME>ICBAD_20ms_PDU13_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b7468976653c3d839c6a7b4b04a0fd1c">
                      <SHORT-NAME>ICBAD_20ms_PDU16_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1ee6ae501a083f4b90012a4699ceb873">
                      <SHORT-NAME>ICBAD_20ms_PDU46_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e281f55160ea3418ba144831838dd4e6">
                      <SHORT-NAME>ICBAD_20ms_PDU48_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e090161962f238279e28d6613378f75d">
                      <SHORT-NAME>ICBAD_50ms_PDU21_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="257705f836e831eb95318433eb411a36">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f302a07304a73735aa2b0a9c97499003">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP09_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="8b325a18796e30b5bc1eff207bc5e410">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="550cf9c8c7783900b13a8c2d6fcfdff4">
                      <SHORT-NAME>ICBAD_CHCANFD_10ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a5d321cf1fba38979b2ad464c139b562">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c677e32c5bff3b7a9dfb472461792ca8">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP16_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="293ee352e7bb3b01a8e1d15428dda47c">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP48_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="ae9bcc60486b3c2c846a717a148e2fc5">
                      <SHORT-NAME>ICBAD_CHCANFD_Event_FrS03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="1865e454711e3a70b967160002942766">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="ffec236bc3bd372d8ed026fa616bd7f7">
                      <SHORT-NAME>ICBAD_RZCUCANFD_50ms_FrP21_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="1a9622183ccc3e1c86de64aa33759d7b">
                      <SHORT-NAME>ICBAD_Sporadic_PDU03_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="2c527bc9735b3113900d0b8c796d6ce3">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4df373d5ea83dd6b0874e9f1704289e">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52f4ca8457fe3063baf7db726906a6b7">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="087f916f94833d7f82bedaafaa32f012">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b97abb322ce312582d2017824b94187">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d9a800e4a6c3731afa42d32c265304e">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3605aa36ee4a362b80ed8df303311f54">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8293e1b601493e3ca2abb8b8c665d565">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="51d354f7a33a3006bddc2dc24161ff34">
                      <SHORT-NAME>ICBAD_ZONE_10ms_Group20_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="5fe46b2193823c7d9faa238bcca8b3a0">
                      <SHORT-NAME>ICBAD_ZONE_10ms_PDU20_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="8a732580e30c3cc78373bcefe6c48464">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd8a1b8b9f143906ae336594f64d1a56">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="683c72fd6a9b3ea8943dec6a90f85796">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cfb8c19eb8413e8eb767c97e42d16841">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc10ef0e13483c81b06d7094aa737a3e">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f80bad3aaf013f21a69721382c279eaf">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b9a9d490d0f3b68a9fdb50936664ddc">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="276b7a3c8781371b98e782827a443cb6">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0745788379fe37aa8e6521db5eae36c6">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="375b32bcffcb39699a53b57bb53cf0fa">
                      <SHORT-NAME>ICBAD_ZONE_20ms_PDU13_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="1608a164108c31c9adf493578adf83c8">
                      <SHORT-NAME>ICBAD_ZONE_CHCANFD_10ms_FrP20_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="853bd1ef135f3dc4833878c6fac48549">
                      <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="7666f58c8b57388ea6a4440910cd4437">
                      <SHORT-NAME>IMUTmp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a257a2c069c3dd693d1f121d0cc054d">
                      <SHORT-NAME>IMUseq_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="36a3f17b23eb37e28ec631811ca86833">
                      <SHORT-NAME>IPD_100ms_PDU35_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="0e2b7001f3b23ae8bef67a83ec2b66f3">
                      <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea162826d63a35df9f3c0c22224adcbe">
                      <SHORT-NAME>IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5fd22c28e443287883277db38837954">
                      <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d1939a65269339e804f4c340f672919">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="82a432168e0e36b8814872ece2dedbda">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="96541d8b84d638be83fb11dfc7091d49">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8863ddc6ca833eea9abf042e33a95aff">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5583d65f6ae333f1a126537d29877fa6">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd36c83185db39e8ae8808db5c065179">
                      <SHORT-NAME>IPD_20ms_Group60_CRC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc3a7ddccbfc37b791f3750d1619477a">
                      <SHORT-NAME>IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9aa8b2f4c893f64b541fafc38e8921b">
                      <SHORT-NAME>IPD_20ms_Group60_RC_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d400ee07630135b387fb10472dfab31c">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved10_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="851698aa5b4f3268b5a4245d283df5e7">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved11_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="189aa240ce2332d5bfa5313344749e95">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5660c5e60ec43928a0728086b5ff3ed6">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5cac785ce89391b84ca7d0b6ddb6f8f">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5bc061d3d4623468893a2db5db88cb4f">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1febf2b3ccec310fa400d5e632382673">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="958830d1cb4b37c2ab9872abb553ecb1">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved7_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1a58e6ce78723b7bad0351a9b33a2595">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved8_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="830acbb3687931ae875b09245f554c02">
                      <SHORT-NAME>IPD_20ms_Group60_Reserved9_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="152ee2e690ab37348056668e581283ae">
                      <SHORT-NAME>IPD_20ms_PDU43_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="50a19c99ba563800a932a9517d8275fe">
                      <SHORT-NAME>IPD_20ms_PDU60_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="9a958c57e10938e6a70695e5024554f6">
                      <SHORT-NAME>IPD_50ms_Group49_CRC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="523bfaf6519d30118592f9a692152e1a">
                      <SHORT-NAME>IPD_50ms_Group49_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="770ba715ca2c3618aa778ba440ba661e">
                      <SHORT-NAME>IPD_50ms_Group49_RC_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa5a8bcab3e6330c8d8b56b872fa8d11">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ad6f65106dc5306bb22a8a6ba7bb4ee1">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ad221b33a2b330aa0fea8021731136c">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f6e61e175fd35c082631a17ffb61635">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved4_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9b1d43bb367a3c8fa2c491ddfe78c74e">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved5_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff1188ca7a0731b29a2742edb892267e">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved6_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="915418ee6f3636b98762d039a65f2edb">
                      <SHORT-NAME>IPD_50ms_PDU49_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="08be97b9f1583ed2bf2ef387ce849e37">
                      <SHORT-NAME>IPD_50ms_PDU62_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="47a3b5fe1cb136b99afbed471e00de5e">
                      <SHORT-NAME>IPD_BKPCANFD_100ms_FrP35_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2bfb28e238b93022a39245a35d7f7eb6">
                      <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4e8977c1f262368f9061f0d49171b885">
                      <SHORT-NAME>IPD_BKPCANFD_20ms_FrP60_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9fe98d9432a235dab18824805a7cadb2">
                      <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="be68506a96083033ba59544f14c1ee05">
                      <SHORT-NAME>IPD_BKPCANFD_50ms_FrP62_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9325590f285733379d130f36cfe4072e">
                      <SHORT-NAME>IPD_CHCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="fc674cc123b733f4a328a96374eb7d2b">
                      <SHORT-NAME>IPD_NKI_CHCANFD_IPD_NKI_CHCANFD_IPD_NKI_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2429dd282a0d30bfb78f490f725776a3">
                      <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD_IPD_NM_BSMtoRMS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1acfe3de91df3e6cbed0ab1563a71ce6">
                      <SHORT-NAME>IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD_IPD_NM_NOSSta_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c522992f24bf319c8a8c64aef4de3afe">
                      <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD_IPD_NM_NOStoRMS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73e133fe3d7f3dc88cd61a072aee20f9">
                      <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD_IPD_NM_PBSMtoRMS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e57dd2a905ed3d72a250ff28c5ff8924">
                      <SHORT-NAME>IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD_IPD_NM_RMSSta_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bbab97b95e2538fbaaf6fc5097c0c118">
                      <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD_IPD_NM_RMStoNOS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0ec66b44e4573ae6bd99b313e97a5301">
                      <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD_IPD_NM_RSStoNOS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="805a19d8ad003b89a90b4070dbb6ae25">
                      <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD_IPD_NM_RSStoRMS_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="063355becb1f35658b637eee577086aa">
                      <SHORT-NAME>IPD_NOI_CHCANFD_IPD_NOI_CHCANFD_IPD_NOI_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b23e86b83c8534848ffa377caf91c9bd">
                      <SHORT-NAME>IPD_NWI_CHCANFD_IPD_NWI_CHCANFD_IPD_NWI_CHCANFD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae0174c840a730359097d06d09a50117">
                      <SHORT-NAME>KeepPwrRsnIPD_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="20ea81ff50f03834a9637325d9236d92">
                      <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e27f037055c63bafa31642a3c5c21359">
                      <SHORT-NAME>LDWLKALVsulznReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dfa9ee40fe20309d92e003e9e92f7f8d">
                      <SHORT-NAME>LDWLKARVsulznReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="816623dd75523c51ab4e2b0a1b627289">
                      <SHORT-NAME>LDWLKAVbnLvlReq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e361eeb62e03337e8eda58248d0ee255">
                      <SHORT-NAME>LDWStsForEdr_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bc1de05e8dc63ac69295d702d77e23b7">
                      <SHORT-NAME>LDWSysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="06dc642ad8243d1bb39ec10c228ff43e">
                      <SHORT-NAME>LDWSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2548b8526ff934808e246117a5889771">
                      <SHORT-NAME>LDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea8c7b282ead31c3bd8814ff22f4178c">
                      <SHORT-NAME>LDrvnWhlRotlDircn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d4344f656d932948feb936dbf81f6f0">
                      <SHORT-NAME>LDrvnWhlRotlDistPlsCtr_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a2da9357c73330b681baaf7b64e0aecb">
                      <SHORT-NAME>LDrvnWhlRotlDistTRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7cb3fa05d95239d6abf24cfdf34e14e7">
                      <SHORT-NAME>LDrvnWhlRotlDistTmsp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="05147c6fd0e93200bf2264a8b51b1bbf">
                      <SHORT-NAME>LDrvnWhlRotlDistV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b05c6aefb6d0368bba8cf18bcf15a9e1">
                      <SHORT-NAME>LDrvnWhlRotlRstOcd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41bf6758aaf831239eaffdb485370c26">
                      <SHORT-NAME>LDrvnWhlRotlSeqNum_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="504655c6153d3f618123196ab15e5eae">
                      <SHORT-NAME>LKAReqAngSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f2a9655479213aeab33da1d47b43ad21">
                      <SHORT-NAME>LKAReqAng_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="10eb3361348d3735bda1aba8cfd44491">
                      <SHORT-NAME>LKAReqToqSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a6a461fae513cc6aebe5250089e063f">
                      <SHORT-NAME>LKAReqToq_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="170e0ec437cd342eb5fadad7fec76cd5">
                      <SHORT-NAME>LKASysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4efd7c2c044b3592ad5d8439707f43a0">
                      <SHORT-NAME>LKASysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ce3cc3fb33443c47a20df13ef25c7e9b">
                      <SHORT-NAME>LKAToqReqValMax_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4307b59581f036929ab67e23b7789e84">
                      <SHORT-NAME>LKAToqReqValMin_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0cb4edbc9a173d0b88c6ca575a1c2ab3">
                      <SHORT-NAME>LNonDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d377e6ac917c3aef9d687add937a543f">
                      <SHORT-NAME>LNonDrvnWhlRotlDircn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e30a698d80d302a8d4024d58d3758f4">
                      <SHORT-NAME>LNonDrvnWhlRotlDistPC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d9a1c5aab6d3a5e9dff5c6ff03ae9ae">
                      <SHORT-NAME>LNonDrvnWhlRotlDistTRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="58ba9137cf7e3f3bb4dcab9dfc8ea9c6">
                      <SHORT-NAME>LNonDrvnWhlRotlDistT_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e48deb31df6f3761a70f6b3542fa6b43">
                      <SHORT-NAME>LNonDrvnWhlRotlDistV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dad8d26d552d32469483c80a51ff02fa">
                      <SHORT-NAME>LNonDrvnWhlRotlRstOcd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c48359abb633e19959b94b4d5017f95">
                      <SHORT-NAME>LNonDrvnWhlRotlSeqNum_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="96ed3cbe5d2f32158c1a84e7d4c5ef0e">
                      <SHORT-NAME>Lane0_C0_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8adc40b7057c3d948aa2755598adb7d2">
                      <SHORT-NAME>Lane0_C1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbe2a92e0df134449045155fe2cba511">
                      <SHORT-NAME>Lane0_C2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a3e669b902b363da9ea346971f9c877">
                      <SHORT-NAME>Lane0_C3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="932ed01fac543971b5810ddbe6f0c830">
                      <SHORT-NAME>Lane0_ExistPrblty_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b1fe196425353873ac6209e32f8e0aee">
                      <SHORT-NAME>Lane0_ID_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="781a0dbc261f3f5c95101feeccd21d94">
                      <SHORT-NAME>Lane0_ViewRangeEnd_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea003a28659235f787c9fa351dfaa23f">
                      <SHORT-NAME>Lane0_ViewRangeStart_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27ffb79d71143149a367e3d17cf71cdf">
                      <SHORT-NAME>Lane0_location_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df0f1ad1f97d30ebbbedbe823d90b99a">
                      <SHORT-NAME>Lane1_C0_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="43b053b0b7f43c92ba15d039b4bc190f">
                      <SHORT-NAME>Lane1_C1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b30ef914e1e73a57941f8178da64f5aa">
                      <SHORT-NAME>Lane1_C2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="64625cdcb912370aa8fbcddd14be104b">
                      <SHORT-NAME>Lane1_C3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d24ee76778de36bdaeb2b1d3a6e2d644">
                      <SHORT-NAME>Lane1_ExistPrblty_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="25053a262779386cb25422a3e02d99e5">
                      <SHORT-NAME>Lane1_ID_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fbdf2a00d7163ce8afc9ba36f29978a0">
                      <SHORT-NAME>Lane1_ViewRangeEnd_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c2cd727acd3237009461fd4503c1f0c0">
                      <SHORT-NAME>Lane1_ViewRangeStart_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7bf6843ff4613d70a26619f18695c965">
                      <SHORT-NAME>Lane1_location_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9f84f458eeae30dc9e95fb28decfd1b8">
                      <SHORT-NAME>MSRA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="044feff919143f4d996a7d0daa5d1e65">
                      <SHORT-NAME>MSRF_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3afbd09b5fbe33babc55eb0b8dea5ef4">
                      <SHORT-NAME>MulColBrkA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c9140b320111310eab47e47f5df7c2fa">
                      <SHORT-NAME>MulColBrkAvlblySts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fef8a4a5f94c32ef924631413ef97b33">
                      <SHORT-NAME>MultColBrkAvlblySts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e03e87aac1f3e33af6af91d05752b42">
                      <SHORT-NAME>MultColBrkEnbA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed3a3d10558f32ccaa848d8add7dcaa5">
                      <SHORT-NAME>NOPSysFltSts_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da816719c71036578d5f2b25d3e2aa50">
                      <SHORT-NAME>NOPSysSts_ZPD_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6e983ea924533b29a745740703c600a">
                      <SHORT-NAME>NSABacSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0f9213c2e713aba83e71afffd0f4a73">
                      <SHORT-NAME>NSADisFucSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff44b0b91fee3c9c91da4ea5ff7716c3">
                      <SHORT-NAME>NSAForSysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef820698c93d3300ba7560f4986bef0d">
                      <SHORT-NAME>NSAReqAVMDis_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="fcd739e8bde0321b86fb7ee0410d8a9b">
                      <SHORT-NAME>NmPDU_CHCANFD_EPS_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cee774cfed8c33f6b6f1d8bf1607c21a">
                      <SHORT-NAME>NmPDU_CHCANFD_IBS_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="983be17a2d5d3bf0be89d59835d482f3">
                      <SHORT-NAME>NmPDU_CHCANFD_IPD_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="dea0ec04b95839b58ad6dc120df94896">
                      <SHORT-NAME>NmPDU_CHCANFD_RZCU_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3f7d69b7881a3715a9787b342c923fb1">
                      <SHORT-NAME>NmPDU_CHCANFD_ZXD_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="dc574e5f6e8f3d299d39dc22e84b5abe">
                      <SHORT-NAME>Parkngslottype_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d9a8b350a623b2196d8550e803fd574">
                      <SHORT-NAME>PilotTkovMsgReq_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45cd2f4bf49b30c3952bb9cdc15c2f45">
                      <SHORT-NAME>PltEPSRdWhlAngReqStsV_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fbcb50f5a20e3359947fca8220d7560c">
                      <SHORT-NAME>PltEPSRdWhlAngReqSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4fc4e5512d463bdbaeaaa5d439da69a0">
                      <SHORT-NAME>PrkgDstCtrlSwResp_IPD_20ms_Group60_IPD_20ms_Group60_IPD_20ms_Group60_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77420fd0f705393c8c9c727385c11d77">
                      <SHORT-NAME>PrvOutSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91f6929cff4e332bb58f9250bc64dce8">
                      <SHORT-NAME>RDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eefefcc53395388b83ed091e06c4b321">
                      <SHORT-NAME>RDrvnWhlRotlDircn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="17b4f700009f3c42a0b981b928764d0a">
                      <SHORT-NAME>RDrvnWhlRotlDistPlsCtr_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a53770248a239aabae34a43af2b5981">
                      <SHORT-NAME>RDrvnWhlRotlDistTRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="511436120e9f31ea9d8e3db492835af5">
                      <SHORT-NAME>RDrvnWhlRotlDistTmsp_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="25842425df143f908e44945ceb78deef">
                      <SHORT-NAME>RDrvnWhlRotlDistV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fd357efee6d436e590cac32edcbc3c20">
                      <SHORT-NAME>RDrvnWhlRotlRstOcd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="acbce1cc95623463a494c5cbbf2d1621">
                      <SHORT-NAME>RDrvnWhlRotlSeqNum_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5db4a70ad023537bcca6fadaade36e1">
                      <SHORT-NAME>RNonDrvnWhlRotlDircnSdslSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b42a04e17b137d2adafe2eec055618e">
                      <SHORT-NAME>RNonDrvnWhlRotlDircn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41983800cb0f3508aa26471d4e74def9">
                      <SHORT-NAME>RNonDrvnWhlRotlDistPC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb792e74777639f4bd5de3ed711311d7">
                      <SHORT-NAME>RNonDrvnWhlRotlDistTRC_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69317a5d79403d34a1581a72e25132ec">
                      <SHORT-NAME>RNonDrvnWhlRotlDistT_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="376471ec2cea32d09f7b4593a1c4c16e">
                      <SHORT-NAME>RNonDrvnWhlRotlDistV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9e2404763439333f97ad63c378c68ca6">
                      <SHORT-NAME>RNonDrvnWhlRotlRstOcd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b4053d568f96303f8eb0bb75eee8700b">
                      <SHORT-NAME>RNonDrvnWhlRotlSeqNum_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="033bd527fa6c331290ec1d9e613e2d59">
                      <SHORT-NAME>RPShockDistL_RPShockDistL_RPShockDistL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0436a6bdbf7b3ffcad65012e4ae6a127">
                      <SHORT-NAME>RPShockDistR_RPShockDistR_RPShockDistR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="f5094bf8bcb3318f8a845068bb4e8a5c">
                      <SHORT-NAME>RZCU_10ms_PDU64_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="99a04eadeafc3c0a8fb12774b046f9c6">
                      <SHORT-NAME>RZCU_CHCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="19cf9498cacd3ba487e7b0549560717b">
                      <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP64_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="b6d285910c3e33229b3926d4dec95d24">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_CRC_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5327e018cd8f3ec9878df90e11bf7efb">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d780795dab3f3651995cbd5e4ad55d7e">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_RC_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f3d1e04719fb376eb9b5d5d04e3ec9cf">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved1_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34a6d2597727398793ef2deb397974a3">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved2_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9049c367c12b353d9c5faa4ea3237cb6">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved3_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d407edb213a3fc9970da3a10d80b353">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved4_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0dd6881625e37998da45401602aef7e">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved5_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37cffe5e5db43390a2cd63e88245d35e">
                      <SHORT-NAME>RZCU_ZONE_10ms_Group64_Reserved6_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65bee350b9d33f6d8133877e7913f6a3">
                      <SHORT-NAME>RgtvBrkFnFltSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="268aaa4278943324b8615f4a0eeabe9e">
                      <SHORT-NAME>RgtvBrkFnSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fe957bad98633c99a88e815938057ff1">
                      <SHORT-NAME>RoadHeightL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e003e6d6c5f93c83ad110c2abfa61a9a">
                      <SHORT-NAME>RoadHeightR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e4a88488c3530729a7291c9e4cc874b">
                      <SHORT-NAME>RoadProfileShockConfidenceL1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d7465d9d18b73b2dada1c5b5eef8bdd6">
                      <SHORT-NAME>RoadProfileShockConfidenceL2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fec1e2cdb6513efab1b5a0e4c0728859">
                      <SHORT-NAME>RoadProfileShockConfidenceL3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b171723e32a3620b7b18b23f085e69f">
                      <SHORT-NAME>RoadProfileShockConfidenceL_RoadProfileShockConfidenceL_RoadProfileShockConfidenceL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31d85908edad35f99387827cc3b26996">
                      <SHORT-NAME>RoadProfileShockConfidenceR1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0184d51eaf5435a1bd0003debf404098">
                      <SHORT-NAME>RoadProfileShockConfidenceR2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="63237c436e49342185ab531390646a17">
                      <SHORT-NAME>RoadProfileShockConfidenceR3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e91c67e4468d3361ac07687945ced492">
                      <SHORT-NAME>RoadProfileShockConfidenceR_RoadProfileShockConfidenceR_RoadProfileShockConfidenceR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dfe256ac74223a9089a549fe9135443d">
                      <SHORT-NAME>RoadProfileShockDetectedL1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0cf85f8db1b23bcab4852b908120709d">
                      <SHORT-NAME>RoadProfileShockDetectedL2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e2e8a476d7432049aeb507d2d3d7246">
                      <SHORT-NAME>RoadProfileShockDetectedL3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30f90d38675431298bcaf967dd32b846">
                      <SHORT-NAME>RoadProfileShockDetectedL_RoadProfileShockDetectedL_RoadProfileShockDetectedL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a29d87f18256302cb436df3d84b2b0d2">
                      <SHORT-NAME>RoadProfileShockDetectedR1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ec161536c2fe30a3b1d2e0a3bc4ad78e">
                      <SHORT-NAME>RoadProfileShockDetectedR2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8a79f9debe0735b4bc0e9bd094a45261">
                      <SHORT-NAME>RoadProfileShockDetectedR3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e72ff899b27235f2a113efc4b9c49844">
                      <SHORT-NAME>RoadProfileShockDetectedR_RoadProfileShockDetectedR_RoadProfileShockDetectedR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ef582d947a430768f7ef46d723fbd47">
                      <SHORT-NAME>RoadProfileShockDistL1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa25ef5456f83b94aa996819c43f352b">
                      <SHORT-NAME>RoadProfileShockDistL2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4a5b55c96cd3cb986a5a0e647c352d5">
                      <SHORT-NAME>RoadProfileShockDistL3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c799230234b63cada16180776586ca48">
                      <SHORT-NAME>RoadProfileShockDistR1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1925829cf7623317b439bf8f65cfd473">
                      <SHORT-NAME>RoadProfileShockDistR2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2554d9049a6936c098ad16925654d054">
                      <SHORT-NAME>RoadProfileShockDistR3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ad66a24ff033215970c1c021603ff2d">
                      <SHORT-NAME>RoadProfileShockHeightL1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="031f84523fa03fbe913dd96f6ccbe7d3">
                      <SHORT-NAME>RoadProfileShockHeightL2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a8d44f1a8f2033df88582eed9c2dac58">
                      <SHORT-NAME>RoadProfileShockHeightL3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81ee1b729a393e3d8ac47a31b10547a2">
                      <SHORT-NAME>RoadProfileShockHeightL_RoadProfileShockHeightL_RoadProfileShockHeightL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9fd62639611f36a6a5faa7f2dd127b0a">
                      <SHORT-NAME>RoadProfileShockHeightR1_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a43e45f7a9d3f4cb9da3e3298609085">
                      <SHORT-NAME>RoadProfileShockHeightR2_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a2a7ac6af1c30c79678f2feb9ddfd81">
                      <SHORT-NAME>RoadProfileShockHeightR3_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d383c72ba58e3a5a83ec6c1a3867323c">
                      <SHORT-NAME>RoadProfileShockHeightR_RoadProfileShockHeightR_RoadProfileShockHeightR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ca1012ff28b3fef8b15f9939b63537a">
                      <SHORT-NAME>RoadProfileShockLevelL_RoadProfileShockLevelL_RoadProfileShockLevelL_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88af2aede8c338f49c515dd51335823c">
                      <SHORT-NAME>RoadProfileShockLevelR_RoadProfileShockLevelR_RoadProfileShockLevelR_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="daa19573fbcc3dfa83a58fae9baddf11">
                      <SHORT-NAME>SAS_ZONE_CHCANFD_10ms_Container01_IPD_CHCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="86c1bc0ee4703bf49bf26ce56686d1f7">
                      <SHORT-NAME>SCSAPAAcclAV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4cea733eb8b337a8bf0f0c3b775abac">
                      <SHORT-NAME>SCSAPAAcclA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9138adb253d83dcdabadb34e8e409a4b">
                      <SHORT-NAME>SCSAutodDrvngSysStsV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3772425435c83c9e882070dbeea7dee0">
                      <SHORT-NAME>SCSAutodDrvngSysSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6fce4ad2a0e335509b73d75848afc87b">
                      <SHORT-NAME>SCSVehHoldAV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="880f2f6226f8365bb4969120e9663702">
                      <SHORT-NAME>SCSVehHoldA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f6aa65a865f381fa16c11b717b469fa">
                      <SHORT-NAME>SLIFSysFltSts_SLIFSysFltSts_SLIFSysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c13cc5135bf374ab866e744e5118923">
                      <SHORT-NAME>SoftSpSysSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="182fd0f17d18369c9b5dd67a35e9441c">
                      <SHORT-NAME>StrgCustSetngDspCmd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d025bbf8b153027a0f94c209710cddf">
                      <SHORT-NAME>StrgWhlAngGrd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75771edc004f37098bb5c62d92c71609">
                      <SHORT-NAME>StrgWhlAngSnsrCalSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="665bb368141437d98c3fe3477e690dd9">
                      <SHORT-NAME>StrgWhlAngSnsrFlt_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab1f808d191733d89460a2f9e660f065">
                      <SHORT-NAME>StrgWhlAngSnsrInid_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f323b9bb3153a1f87ffa61df349b14e">
                      <SHORT-NAME>StrgWhlAngSnsrMultCapb_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88f7844e6cb93043952802ccfc3084b0">
                      <SHORT-NAME>StrgWhlAngV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e3c6012a8ec3c3080f9bc5d974d8b6a">
                      <SHORT-NAME>StrgWhlAng_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b08efaaa93183787a0b97b556a4a9783">
                      <SHORT-NAME>SysPwrMdCtrl_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5e53d57192c3a7e9a57e4e71ff46e84">
                      <SHORT-NAME>TCSA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ff2603422e03b4782399aab5b5cc8f1">
                      <SHORT-NAME>TCSDrvrItnt_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d232de419763d3097075084081594e0">
                      <SHORT-NAME>TCSEnbd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a762face2f3e334680016743870aece8">
                      <SHORT-NAME>TCSOpngMd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b57c8582d100348da16f92ca201f3e67">
                      <SHORT-NAME>TCSOpngSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9335edc1392433c7bfae7aeaebf07aee">
                      <SHORT-NAME>TJAICASysFltSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f139cbd741a335b9820cf5b5c72b87d">
                      <SHORT-NAME>TJAICASysSts_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84e1e87942853d0880865d0cfc318060">
                      <SHORT-NAME>TireBlowoutPos_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4083cd01d79e36b98e96b938b8286afa">
                      <SHORT-NAME>TireBlowoutStabCtrlSts_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_RZCU_ZONE_10ms_Group64_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d8ee47b983f5349f863626a9d5476855">
                      <SHORT-NAME>ToEPSMsgChlg_IPD_CHCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6d1aad3f60f30a3a4514ed27b3aef58">
                      <SHORT-NAME>VSEMd_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="58326f618ca4342894b7162845910890">
                      <SHORT-NAME>VSESts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3ea94163b92035d9a651b71c094df12e">
                      <SHORT-NAME>VSESysA_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="909a3c5e7435325690ca6f939149446d">
                      <SHORT-NAME>VehSdslStsV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="05f4d47ef21e3d61a5adce18f3909211">
                      <SHORT-NAME>VehSdslSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="43225baa73c43e9785cc5a17db704cf7">
                      <SHORT-NAME>VehSpdAvgDrvnSrc_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5070c9a88e4a34ea9bae523d55b87b3c">
                      <SHORT-NAME>VehSpdAvgDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eeb2bad898093a079f6d48bfb59b31b0">
                      <SHORT-NAME>VehSpdAvgDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="310dc6c5026f3ffe91fa8c1a1128b516">
                      <SHORT-NAME>VehSpdAvgNonDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52b1ba74f46431d8ba1f74c643764485">
                      <SHORT-NAME>VehSpdAvgNonDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="521544385ebc319ea4bd743277376b2c">
                      <SHORT-NAME>VehSpdAvgV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="579f0e1d414e37a9af5a5e63d127ce4d">
                      <SHORT-NAME>VehSpdAvg_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b224a608aa53e6e8639692351cae246">
                      <SHORT-NAME>WhlBrkPrsSts_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d9bb63b5c8933708ddcbfe53416e1e1">
                      <SHORT-NAME>WhlGndVelLDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a3210fce2b931e995970a858496b8e0">
                      <SHORT-NAME>WhlGndVelLDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="548c690031343eaa8a52776389fc0f39">
                      <SHORT-NAME>WhlGndVelLNonDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f5724d1933e739c3a76bed3279a83dc4">
                      <SHORT-NAME>WhlGndVelLNonDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50f48ff20bee35ba811a08f1e1101a63">
                      <SHORT-NAME>WhlGndVelRDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d767f305d433b9b82b1eb342ef6cff7">
                      <SHORT-NAME>WhlGndVelRDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="537e810d39cc310baa9ee347dae812b8">
                      <SHORT-NAME>WhlGndVelRNonDrvnV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="44a15f373fed319a91b2b4658b49449e">
                      <SHORT-NAME>WhlGndVelRNonDrvn_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1328cceb93c530ac9d70dadcc1044415">
                      <SHORT-NAME>WhlRghRoadV_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02e9d7e12ffa3e27a5e33ec8654abd53">
                      <SHORT-NAME>WhlRghRoad_IPD_CHCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="f919520b67f5300cabce7f86ba634e2f">
                      <SHORT-NAME>ZXD_CHCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                  </ECU-COMM-PORT-INSTANCES>
                </CAN-COMMUNICATION-CONNECTOR>
                <CAN-COMMUNICATION-CONNECTOR UUID="Oa505a3f19f25843c4b380959xOa505a3f19f25843c4b3809d200">
                  <SHORT-NAME>IPD_PTCANFD</SHORT-NAME>
                  <COMM-CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_PTCANFD1</COMM-CONTROLLER-REF>
                  <ECU-COMM-PORT-INSTANCES>
                    <I-SIGNAL-PORT UUID="8e851d47f616378dbcfc3895dcaaaf06">
                      <SHORT-NAME>ACCAccReqSts_CH_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a0846a7a3bb93464a2fde305ee4fdb6f">
                      <SHORT-NAME>ACCAccReqToqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="572ec324b23437eda7209b3e837b6afa">
                      <SHORT-NAME>ACCAccReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49965fab46143621a1ca7d9ca28b51c4">
                      <SHORT-NAME>ACCDclReqSts_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88f26eaa8fcb35bea7f0b50caa5c3261">
                      <SHORT-NAME>ACCDetObjDistLvl_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2248250c8f483cfe892965a142d36c58">
                      <SHORT-NAME>ACCDetObjExistPrblty_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6c98fdc700d33c9baa4a3adb5088fd1">
                      <SHORT-NAME>ACCDetObjId_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2a6b87a568b3d20b59fc41045e0df69">
                      <SHORT-NAME>ACCDetObjLatRltvDist_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d9f18626e9f3473aa2df511d62ae7fb">
                      <SHORT-NAME>ACCDetObjLongtRltvDist_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="57a909e2c8e73f1a9c58f3c035fdedd8">
                      <SHORT-NAME>ACCDetObjLongtRltvSpd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88fb13ed6cf33434b83e396746143d93">
                      <SHORT-NAME>ACCDetObjSyncCtr_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6eff932552783c11a3c49328adfd2e8f">
                      <SHORT-NAME>ACCDetObjTyp_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eebf74b767b132d6a7e79089765a5928">
                      <SHORT-NAME>ACCDrvrSelTrgtSpd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0bbc255a3b013bf3bfcedb416ba1c8cf">
                      <SHORT-NAME>ACCGoNotfr_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d5b9138ba4d238f4a84b7deead67da22">
                      <SHORT-NAME>ACCGoReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da50dbb52177357cafd7f0b53affaf0f">
                      <SHORT-NAME>ACCMsgReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e26ed5ef563322d9a8c4d299db6400f">
                      <SHORT-NAME>ACCOtptShaftTotToqReqSts_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c49fb6b4ddc3f71a40bfd5a2056b8b5">
                      <SHORT-NAME>ACCOtptShaftTotToqReqVal_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9934afa348e536379be1524dd632cb25">
                      <SHORT-NAME>ACCSdslReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6725aa783b883ebd8e51ac834d08a667">
                      <SHORT-NAME>ACCSeldTrgtDistLvl_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6da7ff98f5a3ba5a434b5efbfcaa834">
                      <SHORT-NAME>ACCSysFltSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="76e4234dd5b53049b5c948085f1778a9">
                      <SHORT-NAME>ACCSysFltSts_SCS_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b46a5ad60f123e29a28fb337f3b46a08">
                      <SHORT-NAME>ACCSysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6c947ffb6401332aa79f293e8769bdd6">
                      <SHORT-NAME>ACCTJAMdSwDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="79c08bebf2ac3da1844f2a821026dad2">
                      <SHORT-NAME>ACCToqReqSts_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="466473b786153dbfb049b85907894bc3">
                      <SHORT-NAME>ACCToqReqVal_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1baaec7750fb3943a5d931882cad659e">
                      <SHORT-NAME>ACCTotWhlToqReqSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a92f8e8b7f73f3c839d00f4d399b7c2">
                      <SHORT-NAME>ACCTotWhlToqReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6e763bfb06230eaa49ed45df3f25752">
                      <SHORT-NAME>ADS_SpdAstSysTrgtSpdV_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1c975c0f928e3f6192ac7354033cc11f">
                      <SHORT-NAME>ADS_SpdAstSysTrgtSpd_IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="67177ec3650b3d1083ff551cc32c9dee">
                      <SHORT-NAME>AEBBrkJerkLvlReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="106e6bf216393081be133c1560e1cd30">
                      <SHORT-NAME>AEBDclReqSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d2973f8cbf9b352bb63fe73115817c67">
                      <SHORT-NAME>AEBDclReqToqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="79c1e0fb110a3f85ad703a397a9543b5">
                      <SHORT-NAME>AEBDclReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="35de0bcd8fe7314f8bede657a05b51d9">
                      <SHORT-NAME>AEBHydBrkAstLvlReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b711815d422638a6b07037779bd5212e">
                      <SHORT-NAME>AEBPrflReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31a1fe1afb433b2d9364ca6f50e7f45f">
                      <SHORT-NAME>AEBSysFltSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27e36d29fa643e72802fcc345871c385">
                      <SHORT-NAME>AEBSysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41a907798ced3363bd838677847020c6">
                      <SHORT-NAME>AIParkngSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ac8ab89c4e430c68bcd42699dca2ea7">
                      <SHORT-NAME>AIPilotSysSaBrInh_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7ea379c72177384ba054cd20bc6dc9aa">
                      <SHORT-NAME>AIPilotSysSaBrSts_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0da6cfaa812734a488d458ece15316d3">
                      <SHORT-NAME>AIPkgAPASCSAcclReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0fb65ae7068f325994e6698cb82e4193">
                      <SHORT-NAME>APACmdEPSSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="29286d2138e537308b77eee192e43519">
                      <SHORT-NAME>APACrpSpdReqVal_IPD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f32239bcf2b337a9ff0194e27d53b93">
                      <SHORT-NAME>APAEPBOPReqV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2feb9973dea73249b2bc9e547edf3c30">
                      <SHORT-NAME>APAEPBOPReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ac6ec15e1fa3503b39655e682bcd382">
                      <SHORT-NAME>APAEnRunReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ede53ab1dcf931d6b79be13749bf30f9">
                      <SHORT-NAME>APAEnToqReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e70c26906723e2cadaed74ffc64a566">
                      <SHORT-NAME>APAEnToqReqVal_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c5a3ae1164c83af981b3cdea1e3872d0">
                      <SHORT-NAME>APAF_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a12dd4fc756b303a99d3a3983af06eda">
                      <SHORT-NAME>APARevrDrgReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0c535ab60f83286ab6ada425e2464f9">
                      <SHORT-NAME>APASCSAcclReqSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="116340136c1338e19f76bb12e1bb1dca">
                      <SHORT-NAME>APASCSBrkFnMd_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="918258ba6b7e35b79fd40379ae13076c">
                      <SHORT-NAME>APASCSBrkFn_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c27063e93b03c46932ab789b0eaecc5">
                      <SHORT-NAME>APASCSDrvrReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="08163803503f37abb4b69c7f50b44f9a">
                      <SHORT-NAME>APASCSParkngPrflReq_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="131b5181bff53aa1b52317ef897728fb">
                      <SHORT-NAME>APASCSParkngTrgtDist_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="136b31e0f88d3be4ac85860e7a63c5a6">
                      <SHORT-NAME>APASCSParkngVelMax_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d40bbd42337390d904a1919d10a6f27">
                      <SHORT-NAME>APASCSReqSts_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="475632530b4c359395a0bf723ba2a44c">
                      <SHORT-NAME>APASCUReqStsV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6ad1efc1067a32e4a80900e81a2e2ea9">
                      <SHORT-NAME>APASCUReqSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="729da5a2544b39d1a12be808fb88aa95">
                      <SHORT-NAME>APAShifterPosReqdV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="59c9c67bfca4361c9ee7051a3d38f020">
                      <SHORT-NAME>APAShifterPosReqd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81e2952a7e763f7e9744b6c03a658116">
                      <SHORT-NAME>APASts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3b55859ef3e235818d473e49266874c6">
                      <SHORT-NAME>APAToqReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="002e304a866136d1a1d407e17bf4179f">
                      <SHORT-NAME>APATotWhlToqReqVal_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a60024646c3393695666a8ddfb98c7e">
                      <SHORT-NAME>APATrgtEPSStrgWhlAng_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f602316b894d32eab76eef99eb84dcce">
                      <SHORT-NAME>APAVCUReqSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cae1ee293da33e09b26fca2e7bac3e5b">
                      <SHORT-NAME>AccelOvrd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e1dc3187dd43ca8bea86214e5fab6dc">
                      <SHORT-NAME>AirCtrlrHVILClsdV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="40bea0620b17382493d3fc43cfae58e9">
                      <SHORT-NAME>AirCtrlrHVILClsd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d13676a3221538f2aef8ddbb12408954">
                      <SHORT-NAME>AutoChrgngMngmnt_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="10374bb336f13938bbaa394a141ca8e2">
                      <SHORT-NAME>AutocTrCmddGear_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7dcb68e61e1134c88d9d3239c6fb6980">
                      <SHORT-NAME>AutocTrGearShftDircnF_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f741eed9ebf311b9e6e1c7754eb08d2">
                      <SHORT-NAME>AutocTrGearShftDircn_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="838c5a3e9a4c36d38ff54e45d1951655">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReqV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4dc416c805633ba98143293bc5dadc24">
                      <SHORT-NAME>AutodDrvngSysEmgcBrkReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a7359d675b839329dd1b8f60e6eb602">
                      <SHORT-NAME>AutodDrvngSysFlrStsV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd6f6d51b0bf384e98487b44ed9e8d8a">
                      <SHORT-NAME>AutodDrvngSysFlrSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69efb32950d83fce8a1c75bda7a6fcad">
                      <SHORT-NAME>AutodDrvngSysMdReqV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f7020d1e0bf36a3bc3ff184f1d8c426">
                      <SHORT-NAME>AutodDrvngSysMdReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ffe95cf1619639a39b391a20faed0c1e">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReqV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fc57ccf35d983a26a04d81e88e7f1d8a">
                      <SHORT-NAME>AutodDrvngSysSCSDrvOffReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f357406bdd933e2789f9784f522ce491">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReqV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="90e9dbc125463a49929323b4ac589c08">
                      <SHORT-NAME>AutodDrvngSysSCSSdslReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3656957c03c93cd89a55ac9f40821644">
                      <SHORT-NAME>AutodDrvngSysStsPT_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0df104c6655c383fb4986da5c01e2795">
                      <SHORT-NAME>AutodDrvngSysStsV_ICBAD_20ms_Group12_ICBAD_20ms_Group12_ICBAD_20ms_Group12_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b0de0cd721a7375ba447c48779614103">
                      <SHORT-NAME>AutodDrvngSysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9f03a4132bd03838a57828edbc7f77e5">
                      <SHORT-NAME>AutodDrvngToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5cd911f911ee3a0ea485ead2e0d4392b">
                      <SHORT-NAME>AuxBatUnAssembled_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db29640f68823bc9888b16a51c3c6d7e">
                      <SHORT-NAME>BMSOfbdChrgrSktVolV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="28bddaba3f403819b2c22dc80fbab457">
                      <SHORT-NAME>BMSOfbdChrgrSktVol_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="40598418750631c7942bb6619cc01bf1">
                      <SHORT-NAME>BMSOffBdChrgrPlugOnV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5dcf631a0b043e5b84a7f15f4006aacc">
                      <SHORT-NAME>BMSOffBdChrgrPlugOn_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="691457f086e83f2c894bb3d75e2779da">
                      <SHORT-NAME>BMS_ZONE_PTCANFD_100ms_Container02_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="2544ae3f147d3905a6b10e774cbcc023">
                      <SHORT-NAME>BarPrsAbsOBD_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef85f3cc43cc3d73b9f085558d2a79fd">
                      <SHORT-NAME>BarPrsAbsV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f3e177be41e332888af5d708c8e9c5d">
                      <SHORT-NAME>BarPrsAbs_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bbf07632b2b7315a95b19820385f14a9">
                      <SHORT-NAME>CCUActiveWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df8b6219bb17305998a047223a94ec57">
                      <SHORT-NAME>CCUClntFlowReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37dd201f930c37a68c09170daeb1a400">
                      <SHORT-NAME>CCUOnbdChrgrMaxChrgPwr_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c850672a89903e34b154b897a9251314">
                      <SHORT-NAME>CCUOnbdChrgrPlugOnV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34263d613fed3cf5af276f72739fb5ce">
                      <SHORT-NAME>CCUOnbdChrgrPlugOn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="17e7e71142333d8a8ab3ff2dcd45fda1">
                      <SHORT-NAME>CCUOnbdChrgrSktEleccLckEnable_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ab7b2f1ee28308db2973195205fde09">
                      <SHORT-NAME>CCUOnbdChrgrSpRsn_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cabe8d746aa130eb90860ffc715ce08c">
                      <SHORT-NAME>CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a97f81e838a23082a8438a2eb86544ad">
                      <SHORT-NAME>CCU_100ms_Group02_CRC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a4dff484ec223226aa3ccd6d0126114c">
                      <SHORT-NAME>CCU_100ms_Group02_RC_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d37e2f00dc7353b86233f36a05b9ddc">
                      <SHORT-NAME>CCU_100ms_Group02_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77cc5ae9ffea3045b2fc85bbbd11bd74">
                      <SHORT-NAME>CCU_100ms_Group02_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a8da00a5b233a1d8c97b7b88dd3fa77">
                      <SHORT-NAME>CCU_100ms_Group02_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b7ec4af9c2f3830a93f01bdb19ac20e">
                      <SHORT-NAME>CCU_100ms_Group02_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9542037d3aac33caaeadd2a68ce1f698">
                      <SHORT-NAME>CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8d5e7ef747136b6ad8f9ac3fcfa8b14">
                      <SHORT-NAME>CCU_100ms_Group07_CRC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6bb57548c5835b4aa2b5909f88ccafc">
                      <SHORT-NAME>CCU_100ms_Group07_RC_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d5d4b15fab633248086ccc335332d64">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved10_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18cdc29e96703548b0ae755be968ddf8">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved11_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="adb28c11374c38b0aa4337837914c049">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved1_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d4392753ca28353cbc9ec97dafd9de0d">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved2_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f901787e879a324c9bea6f07ca351674">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved3_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f3969ef4e6713c3ab5a0ba0285ccb06a">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved4_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27f78f30da033160b4b9a61b1ecdb4ce">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved5_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb5f0e3a7e3a3e95bf7ed144bbc078d6">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved6_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7f946aac62e3ada80174925b9570962">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved7_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19051eaf8a1a3ebfac6f11342eeb2d43">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved8_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f31595107ef031b5a4da3e66896301b8">
                      <SHORT-NAME>CCU_100ms_Group07_Reserved9_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c142b79e0de391fb3f66a7ad3f9f921">
                      <SHORT-NAME>CCU_100ms_Group11_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5d3489c20382388a9381eac4c71b9323">
                      <SHORT-NAME>CCU_100ms_Group11_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab0b66f727893b9f80e0d8a411b78fd6">
                      <SHORT-NAME>CCU_100ms_Group11_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c6c77dbdde93adf9e2190957c99b0c3">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved10_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="451cdfdd9ea83fcf897eaf8b7f00ebb8">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved11_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1f4febd07b173bb5b68292316d3c2cab">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved12_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f586028911b3873882a9ba780ccc2e4">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved13_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37f87ed458c138a1879fd382edb8659c">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved14_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0e2b05cfd0fd35839e569b10923084f4">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a1105e9e7b86370da2dd93eb5fe44d90">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fcc1a95fee363dbe8218d5906e789c28">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fa02df6f459d3a75ab4b22ef48554520">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e7b692696413365a03e9e0bcb976cc6">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1e79c1b2b541332282342594b171ef45">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f24f4afcc7203582a904f1234329ab8f">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45801639fe473317923fe4cd398b5e0d">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved8_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d1bf171dfb2b38e989cb3363bfdbd01d">
                      <SHORT-NAME>CCU_100ms_Group11_Reserved9_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="77d94b883ae837cea3fe083ab32250bd">
                      <SHORT-NAME>CCU_100ms_PDU02_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b58d9b9c1ffd350187a1fb3b648325bd">
                      <SHORT-NAME>CCU_100ms_PDU04_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c596c37bc9693328b8cdd969e2c62ae2">
                      <SHORT-NAME>CCU_100ms_PDU07_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="41a0aaecfbbb3025b272feffbb5d7bd6">
                      <SHORT-NAME>CCU_100ms_PDU11_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="2abdca959f0930a3ace47a73e4c2c2c0">
                      <SHORT-NAME>CCU_PTCANFD_100ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5ab38a25ad693973a2b4795754ec9c99">
                      <SHORT-NAME>CCU_PTCANFD_100ms_FrP04_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="baddc032eb8b388e810cbbb7be3f7ece">
                      <SHORT-NAME>CCU_PTCANFD_100ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5f1216dc1d873691b894a1732807f48f">
                      <SHORT-NAME>CCU_PTCANFD_100ms_FrP11_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="545df0f7c02830fdaa54c8c425970a05">
                      <SHORT-NAME>CCU_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="48f61adeab0f38af8815af2d77c2d80c">
                      <SHORT-NAME>ClOpenReqA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d838d6d3d063bb7b4be405651519b29">
                      <SHORT-NAME>CluActTorq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="69fbbe2019da3455866ee0b472521fcf">
                      <SHORT-NAME>CrkshftNonTrRegdCmddToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a83bbb987bc33c379cfe0c5aa087460b">
                      <SHORT-NAME>CstRgtnBrkLgtReqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="059cc719057e3a96a9a6c33c5e4cca07">
                      <SHORT-NAME>CstRgtnBrkLgtReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="479b43ba6ffa3fd58a9fe88d57e83f77">
                      <SHORT-NAME>DMSSts_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53e61c4cf411305b9476177e6184c91c">
                      <SHORT-NAME>DrvlnToqStabSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="56be0aff951f3e7489a75ffd4c869b05">
                      <SHORT-NAME>DrvrReqFrtAxleWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1b925d9e01c315c9f23d74c0af1daf6">
                      <SHORT-NAME>DrvrReqFrtAxleWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c40aa4a1bcc375aaad2bbf5e563bda3">
                      <SHORT-NAME>DrvrReqRrAxleWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c113ad0b3cc34afbe42b9c2e365b5f3">
                      <SHORT-NAME>DrvrReqRrAxleWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a82be9fc355e3fc988c7b42c6e3d06c1">
                      <SHORT-NAME>DrvrShftCtrlReqDndIO_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea65cee7cb9935ee8e5e30469bee8af4">
                      <SHORT-NAME>DrvrShftCtrlTrgtGear_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="beada24e699e380dbc6f737855b8b51e">
                      <SHORT-NAME>DschrgOptMaxPwr_DschrgOptMaxPwr_DschrgOptMaxPwr_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="21ca99caedd7328a9600c1dba2220211">
                      <SHORT-NAME>ECM_010ms_Group00_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73ece1a019733d848e9757295965b6e9">
                      <SHORT-NAME>ECM_010ms_Group00_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1db1285852b83f848de78359e3ac6dab">
                      <SHORT-NAME>ECM_010ms_Group00_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="403a88195467351793db812587e431c9">
                      <SHORT-NAME>ECM_010ms_Group00_Reserved39_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="260ab72ab596317792368808ac0c92b9">
                      <SHORT-NAME>ECM_010ms_Group00_Reserved63_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="195431044b78306c8061390fc273c7f3">
                      <SHORT-NAME>ECM_010ms_PDU00_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="35cf8680a63d3c8f92f6a797105f61a4">
                      <SHORT-NAME>ECM_020ms_PDU03_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e77d9d4272383ba69978feb9d1a076f1">
                      <SHORT-NAME>ECM_020ms_PDU03_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="93c8e65a20003ea8878162dd71c7acdc">
                      <SHORT-NAME>ECM_100ms_PDU11_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="6106d6691d643f2ca66257627db12ccd">
                      <SHORT-NAME>ECM_25ms_Group36_CRC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68850435f6c03c44947b9744a8a3b0db">
                      <SHORT-NAME>ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb5de3a727753aca91c5b20b7491ccd5">
                      <SHORT-NAME>ECM_25ms_Group36_RC_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9744ea8bfee3782848df156738827fa">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved10_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99123acd7619368fa87d9c9f6689a768">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8db4cc825d3a33a1829a677ed598e910">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f573b81742ad3b84b88d7e0446d57581">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6ab6715fb323399a25b22c24087e195">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="46cdb2eae449371cb8bc8ba0daf8bde6">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2a3c52e45dd32a0aca0dfdcb8cfae93">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e1686fddd184371f9749d08812305a08">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f3f6f17a2fe73583a94eeac1af5037af">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved8_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5fec28bbac8436f0bb63db4b3e0ef17b">
                      <SHORT-NAME>ECM_25ms_Group36_Reserved9_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="2bce9c966afd30b4992e6bedb946a431">
                      <SHORT-NAME>ECM_25ms_PDU36_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="184c0b2940b03faba2e73f89f1733bda">
                      <SHORT-NAME>ECM_500ms_PDU14_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="524122009b6834248b37e7148d992940">
                      <SHORT-NAME>ECM_500ms_group02_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91b7a58d231931699adc9a06211c3dc6">
                      <SHORT-NAME>ECM_500ms_group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="848c27be0fc037df8b366130212b70d4">
                      <SHORT-NAME>ECM_500ms_group02_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d480f126ef50345b854e6ca873851504">
                      <SHORT-NAME>ECM_500ms_group02_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="53a32bc7f0943f2d8bcd637c39bdc564">
                      <SHORT-NAME>ECM_ERCANFD_100ms_ConFrP10_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="9e68fce351bf317ebec89ad4aeb39947">
                      <SHORT-NAME>ECM_ERCANFD_100ms_container10_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="7963b819c80835e6a2af0508f4047b70">
                      <SHORT-NAME>ECM_ERCANFD_10ms_FrP00_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c1f8c10ea8dc3c46815c52fe9c2d109c">
                      <SHORT-NAME>ECM_ERCANFD_500ms_FrP14_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="06ededcf2e783629a35fd1126da0e729">
                      <SHORT-NAME>ECM_PTCANFD_25ms_FrP36_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9d93f65492e23e2ba590aefdd107d567">
                      <SHORT-NAME>ECM_PTCANFD_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b0cfeb7671da3792998828c42272fab3">
                      <SHORT-NAME>ECM_PTCAN_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="60b23bc7d75634d68613caf5de7aa827">
                      <SHORT-NAME>ECM_ZONE_020ms_Group03_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fd8b7d834b523abd96bc0c8651b1b398">
                      <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="55be63cfd5a638eea387feee4bc4edb2">
                      <SHORT-NAME>ECM_ZONE_020ms_Group03_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="899022755044380fa736e15b55b6d272">
                      <SHORT-NAME>ECM_ZONE_020ms_PDU03_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="a4d74894f96d37a3a16e03e8c7cfd641">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_CRC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ab690cecd96399e8d4fb44b6f01ac3b">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8403e66b6334318fb78841170375c4ec">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_RC_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f0ba1e25c580388fad0b9a8213b6b3be">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="337fdb9ffd973809a35bf469812a5e46">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0733c5914958394e9d74ece480c48db0">
                      <SHORT-NAME>ECM_ZONE_050ms_Group09_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="5aa9905b1a2e3cd5852a4d6cdd6298ee">
                      <SHORT-NAME>ECM_ZONE_050ms_PDU09_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="215efe69ed7b30808f6d01701c36d8ce">
                      <SHORT-NAME>ECODrvngSpdRutA_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6a25df4fd303dc49a0d509c54bd2444">
                      <SHORT-NAME>EDUClntTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="60a1de3943293898858af6a70e72fe09">
                      <SHORT-NAME>EDUClntTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4694d6b5cf7430f28771910965596de4">
                      <SHORT-NAME>EDUOilTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9038c7b9eb3f3b05839c196558ee42ad">
                      <SHORT-NAME>EDUOilTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54a6d667e9293caeb43a11c9499c7f03">
                      <SHORT-NAME>ELKSysSts_IPD_FVCM_20ms_Group02_FVCM_20ms_Group02_FVCM_20ms_Group02_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b083861aa0963449bec41a2093ac207b">
                      <SHORT-NAME>EPMCurEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f024f20d65fd31eea764c1a37308c149">
                      <SHORT-NAME>EPMMaxEstdCapct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94eb8ede2b9737028a1005ea1482155c">
                      <SHORT-NAME>EPMOprtMd_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cedfa007f3643e66992016492cb0a965">
                      <SHORT-NAME>EPTAPARevrDrgReqResp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aa2080e97b613cd1b5f170dd99cea7f6">
                      <SHORT-NAME>EPTAccelActuPosV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e10b58382f13369b9f7532e29850e188">
                      <SHORT-NAME>EPTAccelActuPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81d7edc96c9a3317829b080afe7c9b87">
                      <SHORT-NAME>EPTAccelEfctvPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="527b8e953f16398e8c44ba6e7767c582">
                      <SHORT-NAME>EPTBrkPdlDscrtInptStsV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab9b28f054643e579ca60af4541aec12">
                      <SHORT-NAME>EPTBrkPdlDscrtInptSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ce162e66e2c3d74bdf05b82f1cdf24f">
                      <SHORT-NAME>EPTClntPumpSta_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d532112f3f6832b394ea5e21deb7d217">
                      <SHORT-NAME>EPTCrkAbotd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24b67d10e7de33ff8b7c3e93f64f2555">
                      <SHORT-NAME>EPTElecWtrPumpActuSpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c336da4cb1c33eeb6612fefdacda596">
                      <SHORT-NAME>EPTHVDCDCMdReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2168751038d23f5da396ce7306d5c6cf">
                      <SHORT-NAME>EPTHVEmgcPwrOffReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="369c1aa6f3c73450a109c4f0e98c871b">
                      <SHORT-NAME>EPTMainRelayDrvReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="583a55c0d15e31faacb7cc8e0b096704">
                      <SHORT-NAME>EPTRdyV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84c10f2f5cd93ae6bd970ef9556dbfeb">
                      <SHORT-NAME>EPTRdy_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d17b808ae30c320c9261d2fe8b409db5">
                      <SHORT-NAME>EPTSecyAxleInptShaftSpdV_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="deab637084e33777b61fa751abb4e981">
                      <SHORT-NAME>EPTSecyAxleInptShaftSpd_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e2de640a790d3a019a3de04730093a5b">
                      <SHORT-NAME>EPTStCmdOn_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbd4554031f73568beb1eda94060d604">
                      <SHORT-NAME>EPTToqCustSetngReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d1bdafa7c6c3027a24d6a7ff95b3a43">
                      <SHORT-NAME>EPTToqCustSetngReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4794fdd125933acfac8d95fdb8d27992">
                      <SHORT-NAME>EPTTrInptShaftSpdV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52ab3fae8ce23513a015ba3144e360bb">
                      <SHORT-NAME>EPTTrInptShaftSpdV_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37e9969959283b63b6d33d5b3e637308">
                      <SHORT-NAME>EPTTrInptShaftSpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="034941b026303dc1a8f7a95eb541e8b9">
                      <SHORT-NAME>EPTTrInptShaftSpd_R_RZCU_10ms_Group02_RZCU_10ms_Group02_RZCU_10ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="29e2d9a95303389c900727d64c9a463e">
                      <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e99e327c8f4a3d399007d18fa620c7d3">
                      <SHORT-NAME>EPTTrOtptShaftTotMaxAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3950e0516af3a1da9f03886da406d28">
                      <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="32850318afe732db8d084f8e41792791">
                      <SHORT-NAME>EPTTrOtptShaftTotMinAvlblToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8e9e6da8e7853d9281aa673da31ede5f">
                      <SHORT-NAME>EPTTrOtptShaftTotToqV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22745a78218c3c5192c7f0aba75d8943">
                      <SHORT-NAME>EPTTrOtptShaftTotToq_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="838a12823dfd39f8911d6e64dfa50ddc">
                      <SHORT-NAME>ESSPTCHVILStsV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3de1c646e16336acbaabdee3d057ff02">
                      <SHORT-NAME>ESSPTCHVILSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f958751ad1a93763bb46cc451f028d49">
                      <SHORT-NAME>ESS_100ms_Group58_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb357b34010e3fe1b80543021facb3cf">
                      <SHORT-NAME>ESS_100ms_Group58_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b106c1dea4f83485982c59475aebdf05">
                      <SHORT-NAME>ESS_100ms_Group58_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83d536f8dc1036bc81206e86789e005c">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="015733a9cc27313eac5a8bb04036911e">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="85f5fa9297353fb893842aa7f0484a98">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7085fcdf4c533289a560fdfa4c35769">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b6ba6a03227318fb4c4e5c17604a74b">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d7d47b4eff537248fc0bb0f22629e75">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9344425cfb33b6593bf3acd3699179a">
                      <SHORT-NAME>ESS_100ms_Group58_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="44f3551ade2038ae8f3f17c9ab1ebb41">
                      <SHORT-NAME>ESS_100ms_PDU58_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="8d4826be390835239fb919fbe7b9b48e">
                      <SHORT-NAME>ESS_PTCANFD_100ms_ConFrP19_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a516294dc1e43d1a8484bbfb0a612828">
                      <SHORT-NAME>ESS_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="9abaa3f857c53b5ea548398e6dc43c64">
                      <SHORT-NAME>EcoDrvngAIO_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7bbc46993a6b39d78c44c5ac485c96cd">
                      <SHORT-NAME>EcoDrvngDspStsGearShftIndSts_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b76f09ab7ec3b97a19f35b91998a1da">
                      <SHORT-NAME>EcoDrvngDspStsRcmndFwdGear_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="86abc0531bed3fb0b0efbcbb8153a5ab">
                      <SHORT-NAME>ElecMotEmgcShutDwn_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b91b0df2f56a3ca89c0a7e080e1d28e7">
                      <SHORT-NAME>EleccLckCtrlResp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="42a900aff2e7373ba40c9208a0f77b5f">
                      <SHORT-NAME>EnASSFrngDet_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d7a1c8a6ba13f1385876694d890ef32">
                      <SHORT-NAME>EnASSFuelReqdOn_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c995eba400d73526be195e7e10fbf471">
                      <SHORT-NAME>EnASSSta_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="744edf82620b34518f3407d1b574a928">
                      <SHORT-NAME>EnASSStallDet_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a57ffa14ad6732d283e81b9437b73439">
                      <SHORT-NAME>EnActuStdyStaToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ccab03b33c43168961fc51dd447bf79">
                      <SHORT-NAME>EnActuStdyStaToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d434fb41287731c2bef5b5ab9b0587a5">
                      <SHORT-NAME>EnAutoSpNotProb_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="02c39405818834128b27f02778ebce79">
                      <SHORT-NAME>EnCCMd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7bbdee797d243da5b5a23be54dc38f9b">
                      <SHORT-NAME>EnClntTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb188f768a993fea82faddb4380e52e2">
                      <SHORT-NAME>EnClntTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="78ecd7e66c93391f969ffa06aee2ef38">
                      <SHORT-NAME>EnComFlrRducdPwrCmdd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d530ef070ddc324691195c50d136214c">
                      <SHORT-NAME>EnCtrlrRunCrkTrmlSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="22bd4b7413ff36918cb160541c930424">
                      <SHORT-NAME>EnDclFuelCutOffAld_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9b9188f86923855852068e3356ad434">
                      <SHORT-NAME>EnDclFuelCutOffReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a51aee29516a32a5a7b3b7401f27b570">
                      <SHORT-NAME>EnDclFuelCutOffSta_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d5f670d55ce3c5889f0c00cc42b77f5">
                      <SHORT-NAME>EnFuelCutA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0c10daf9acdc31ec8bc3d43e00a4231f">
                      <SHORT-NAME>EnFuelRcvrySpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="28e1af00181233de83faadc9163a8690">
                      <SHORT-NAME>EnHybVehStaOvrd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="26e640ee554e37dea1102d5a1e350541">
                      <SHORT-NAME>EnIdleCtrlA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ff8bb76138637ed99158dabc6baf4e9">
                      <SHORT-NAME>EnIdleCtrlSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9db5300678323dd89754a2a0f6b8470d">
                      <SHORT-NAME>EnIntkAirTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5ee1e88b7d4b3c7c873ab5825cf40118">
                      <SHORT-NAME>EnIntkAirTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b54e53cb9dd3059aaa65bde02839dbe">
                      <SHORT-NAME>EnReqdStTyp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="34622c83e2b8310793b287a9c2741e24">
                      <SHORT-NAME>EnRunA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e9138a6ec34b39669e0b73b0a819edd7">
                      <SHORT-NAME>EnSpReqToTr_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="719a880a2a183d629be1f686190d0a94">
                      <SHORT-NAME>EnSpdSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="42f9209e5bbe3704844d5379bad91ed1">
                      <SHORT-NAME>EnSpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cd3fcb9d91733860904cc5aa16310298">
                      <SHORT-NAME>EnStCtrlA_PICU_10ms_Group23_PICU_10ms_Group23_PICU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7753b412af26334588f73c609fc37e48">
                      <SHORT-NAME>EnSynRdy_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="14d3574ab4f232b0b3bf1693e177e79d">
                      <SHORT-NAME>EnSysDsbld_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c48209042ee537c28179458cbddeb0ba">
                      <SHORT-NAME>EnTestMdEnbReq_ECM_010ms_Group00_ECM_010ms_Group00_ECM_010ms_Group00_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f20d10fa34323ff1bbc0795296bb4d36">
                      <SHORT-NAME>EnToqActuExtdRngV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae82461dc156388da1f62a54fbfd4cae">
                      <SHORT-NAME>EnToqActuExtdRng_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1159f4ece5f332a3aecfc9d3f39cf63a">
                      <SHORT-NAME>EnToqDrvrReqdExtdRngV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7548ab36f0338bab6b499f5b0bc390a">
                      <SHORT-NAME>EnToqDrvrReqdExtdRng_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91eaa79bd9833997a84a891385b715ce">
                      <SHORT-NAME>EnToqMaxExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3cb8e4c883833a15a4176e6fcc2aa623">
                      <SHORT-NAME>EnToqMaxExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c7e27e9c65935909abacfe2454397d0">
                      <SHORT-NAME>EnToqMinExtdRngV_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5ad19f137f9329f961ce4b0bc590b80">
                      <SHORT-NAME>EnToqMinExtdRng_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_ECM_ZONE_050ms_Group09_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e9f0a6686ff93743b33baa94bea877e3">
                      <SHORT-NAME>EnToqRducnFlrSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04481d1559813e0a80d10de62e0f1a94">
                      <SHORT-NAME>EnWarmUpCycAch_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3ad5c0f1404339949ba6d7f74bf51418">
                      <SHORT-NAME>EnrgSplReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="585c0b3db5d23bcd824cfd7aed1205fa">
                      <SHORT-NAME>EnrgSplReqV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e390281f3b8c387c9d57ef4b0a8b5de0">
                      <SHORT-NAME>EnrgSplReq_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19ce26d94e6f3cc2bb05fe4b8df26597">
                      <SHORT-NAME>EyeOffRoadDetnStaV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd472af3e0d5354aa9baf325c9a45c8d">
                      <SHORT-NAME>EyeOffRoadDetnSta_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c23276b42fc3d2595ab86b8ada84def">
                      <SHORT-NAME>FVCM_20ms_Group02_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="10678e0ceb6e314ebcce567804c3ba47">
                      <SHORT-NAME>FVCM_20ms_Group02_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd740dd4e1e9356b9a272a7e00f06307">
                      <SHORT-NAME>FVCM_20ms_Group02_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6f440593e3453a618152569a47a54e22">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0acd9d70900c3ff7b35fde89fc3ff12b">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2594bab638cf36a9a9e0b08bd0a8e7d0">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7277de5d97503cfdbfa404efaa7cc78e">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db184b4eab6d3b84ac72a49aa9032be9">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6b21506efec83d2d8ec1dcb6b6cc6eb7">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f54ff1ea33d232d099ae43083d8bb78a">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved7_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="666560c5eaf43f48bbb5ba3297e9b638">
                      <SHORT-NAME>FVCM_20ms_Group02_Reserved8_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="03f5482508d13b6fbb41aef4f959561f">
                      <SHORT-NAME>FVCM_20ms_PDU02_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="378541f8fc1e35fb80f682b671ceaabf">
                      <SHORT-NAME>FVCM_BKPCANFD_20ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="a29e7f32bb2b317c8c107b2f0985f0f4">
                      <SHORT-NAME>FlbStrgFnStsResp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0fd5c319cbd1318bbda12a3d25c9121f">
                      <SHORT-NAME>FlbStrgFnSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="93983c9a08d0387d81cace6c8e7669a5">
                      <SHORT-NAME>FrtAxleActuWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d087de295742395ab9ecdbcd40f425c2">
                      <SHORT-NAME>FrtAxleActuWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0454586f1543a21a331ada6f21b9f0d">
                      <SHORT-NAME>FrtCarGoNotfr_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7cf0301bb0b3323482630a636f4ba797">
                      <SHORT-NAME>HVDCDCClntPumpPWMReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1e510a7df9d33a11a2f9876fbbe40893">
                      <SHORT-NAME>HVDCDCHdwrFlr_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="07ed4163c5633cda8b643831f46aa6e2">
                      <SHORT-NAME>HVDCDCIntnlFlr_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e743ccfd4e5c3927aa240ca5e7fde216">
                      <SHORT-NAME>HVDCDCSta_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="76bf737ff5b03e028c9415e1b339b19d">
                      <SHORT-NAME>HVDCDCTem_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb592edd9e1a353d8fe30b28c920084a">
                      <SHORT-NAME>HVDCHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="485f16ca584b31cf978f9ef04ae91b27">
                      <SHORT-NAME>HVDCHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c545d804d573016b77651ef8179d8f5">
                      <SHORT-NAME>HandOffStrgWhlDetnStaV_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f7ca81e46f43ad78fc3dafe8bfadfa8">
                      <SHORT-NAME>HandOffStrgWhlDetnSta_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81b2f8f23c403eaaa817a0f010d4e515">
                      <SHORT-NAME>HybAPAAvlbl_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49f44df766ca3e1b8515d183f85ef5c1">
                      <SHORT-NAME>HybEnSpdReqF_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41f6d8de72d9382f94b8dc6d2d357018">
                      <SHORT-NAME>HybEnStSpOvrd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="842c0b8df8a63832a3e20e8d0c75ef74">
                      <SHORT-NAME>ICBAD_100ms_PDU29_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="2a8a9fe6ddea3e8585b7360a3ee53059">
                      <SHORT-NAME>ICBAD_100ms_PDU36_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="11635dd3743635d481504df622e2aca0">
                      <SHORT-NAME>ICBAD_20ms_Group05_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb20066028e6346db01c319ac6460296">
                      <SHORT-NAME>ICBAD_20ms_Group05_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bc796fa2885437ad867727f323bfbbcd">
                      <SHORT-NAME>ICBAD_20ms_Group05_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e534d3094e493c6581079158ea9e28fc">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved10_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="043b3a5f5b0134019a2fea5f261b22c7">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved11_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c4dc7f8b32db36218d70f130a5b4dce0">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved12_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6f02eaba3753b9c8b1932eaa1f15668">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved13_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c5283c4b1003d58bbb0a75e3ad6f4ad">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved14_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="73f8fdf3c3fb379e9984d8193e91ed55">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="97c462826467332a9bb73350a4724c6c">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="58557be6d6a537fc808b493d364dce21">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aff929fb55e13c75a61f44e9b3bd4816">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="12ab4fe9fffb3d7fb989b3d5bcb04b57">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a6b8cbbf16423b949deb167b808cf43d">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="09b0ab47531331abb845da68ae6c5d3a">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="23136004204f3c1a82ec025771da4ef8">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved7_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6e536df8b3663a828d40e9015df5467c">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved8_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f83bc2c3f38e3a629986ef32861895ae">
                      <SHORT-NAME>ICBAD_20ms_Group05_Reserved9_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04bebb78227f36e397674c818bd53891">
                      <SHORT-NAME>ICBAD_20ms_Group07_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f678c7d826c4345f9535fd69bc36cf50">
                      <SHORT-NAME>ICBAD_20ms_Group07_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="064ad1f736753037a4860a9945840599">
                      <SHORT-NAME>ICBAD_20ms_Group07_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b4b3713d4a0f3fc68282a51e67391cb0">
                      <SHORT-NAME>ICBAD_20ms_Group07_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd574ace72a33c678fa86613bca94465">
                      <SHORT-NAME>ICBAD_20ms_Group12_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a1cf10345923a93a922b726786c9807">
                      <SHORT-NAME>ICBAD_20ms_Group12_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5693f0a107e535678c82888d0290ae0e">
                      <SHORT-NAME>ICBAD_20ms_Group12_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="814ba1c907c83e33a4bdf14b98766203">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3929b6c0e5533c16b0b6161a8c49e8aa">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0d64efd2bbf3ce0a851d0c1531adef1">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f07ce7f7f7b3cf282aaeecd44c35179">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9ca3aa658b330e293d7c2bfa0874fbb">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="71b3fab647783c51ae64025efae82382">
                      <SHORT-NAME>ICBAD_20ms_Group12_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ffecdd66c5938e48a0173e9ee3f8451">
                      <SHORT-NAME>ICBAD_20ms_Group13_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9d130204f5630b695e853bca6d349a8">
                      <SHORT-NAME>ICBAD_20ms_Group13_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e729cfb9b783dc1b65479ab96df916d">
                      <SHORT-NAME>ICBAD_20ms_Group13_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f39f5dc8b07f36d7a2c9d269da5a4457">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab0d94ec10d03ba9968b244c3249ff94">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="711ce98aa1523bc5b38764c23033e261">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="246e2542e7663f6ca06b2f65aae5cb71">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="305e025d1f8a341195bc824be8203e0b">
                      <SHORT-NAME>ICBAD_20ms_Group13_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72e92b761a3b3dff8e480eafe7b7ee89">
                      <SHORT-NAME>ICBAD_20ms_Group15_CRC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cdd76a6d5b263d729f955de550d1f926">
                      <SHORT-NAME>ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="071a217be5f63e0da47681021939aa98">
                      <SHORT-NAME>ICBAD_20ms_Group15_RC_ICBAD_20ms_Group15_ICBAD_20ms_Group15_ICBAD_20ms_Group15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a24334e345130f0b3dcc8ab4a433524">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b091ca552a9343bae21e7514696a63b">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1e8b4a85d99637cc9feba4e4fb0734b2">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed2e05a123ef36f38be31e617f5d6200">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c543f91237833aaaab66cd4e6bf17fef">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8df31d3924b3c18ac898745eeb75180">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0fefe241d2b368cb53dfb3f7667fe1f">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved7_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="794f7b9472dc376d957955573e646e82">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved8_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b5df2e3b7688326e8c8066e73492d74e">
                      <SHORT-NAME>ICBAD_20ms_Group15_Reserved9_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="be873dff3d84376784af79cc128167ab">
                      <SHORT-NAME>ICBAD_20ms_Group46_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="443f611beac63188945045fff61f330e">
                      <SHORT-NAME>ICBAD_20ms_Group46_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27f51d3ecc183d27a193f67655db7464">
                      <SHORT-NAME>ICBAD_20ms_Group46_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ce2429f10a933738661d373b8feff6d">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b361bd4a08c13625acb1703ae3799dea">
                      <SHORT-NAME>ICBAD_20ms_Group46_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="6296efd1899239bc888b8af9e0eb1d99">
                      <SHORT-NAME>ICBAD_20ms_PDU05_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="578fd686e8e73d22971dbb6b10579d88">
                      <SHORT-NAME>ICBAD_20ms_PDU07_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e5ce450f9b9a353a9d56b1165ba7d76f">
                      <SHORT-NAME>ICBAD_20ms_PDU12_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="3f6e31bfc9bc3e7caf45abbd155b1cea">
                      <SHORT-NAME>ICBAD_20ms_PDU13_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="692833282e6d3ab583d223bcddbdacf5">
                      <SHORT-NAME>ICBAD_20ms_PDU15_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="858386a21cf5354c9d7cf8c5a9a7b341">
                      <SHORT-NAME>ICBAD_20ms_PDU46_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="a77190d7900f30d08f9a9810bbf8bf84">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP29_NoSecOC_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="0d62c173a10c3167afe5000f261d0cb8">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP36_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4ed19ff1df433d5cb1b67dac644cd894">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP07_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="11e839031acb37079563fd14bea0f161">
                      <SHORT-NAME>ICBAD_BKPCANFD_20ms_FrP46_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f6aa8512e56235df93a04a42bcf9429b">
                      <SHORT-NAME>ICBAD_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f73810fe96d23395b6cb2a96dfc08abb">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="52da9349f9713ab09785f2cfd3e3af53">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP12_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="6c5f3970c8093bcebfc664da094ef2d9">
                      <SHORT-NAME>ICBAD_RZCUCANFD_20ms_FrP15_NoSecOC_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="99c4bf3fa3ab30ec9cb0f539c48169d7">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47e865ff41693bfd9c79af8406515336">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b66f37ad2e9c372fb4cb9bbdc1b0d7a5">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d589a88b7a238a0ae2b93e525b87242">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d005d7d2c79d3a1dac90043b1349d7b2">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d0df62c02263337583409bf96c7a9532">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d6c79158e74531dea095176c7d7ed77b">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="08653de9a80c37d98d0a5c1fd848e2d2">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="488898fe0cf53c5c831f7f914bbea967">
                      <SHORT-NAME>ICBAD_ZONE_20ms_Group13_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="1a85702a9b2b33169594d8b13a6f3c47">
                      <SHORT-NAME>ICBAD_ZONE_20ms_PDU13_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="d0765b5e471c363c8441354e335b47e2">
                      <SHORT-NAME>ICBAD_ZONE_CHCANFD_20ms_FrP13_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="cbe2503c2e9b38b9a909c5e80587ad77">
                      <SHORT-NAME>ICBVC_100ms_Group19_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54ae926f2b4f38dfab05de4dc83ba41e">
                      <SHORT-NAME>ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0d20c726090a356ba83d716c120b094a">
                      <SHORT-NAME>ICBVC_100ms_Group19_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d2622da7a1131e59f6b634838ed19dc">
                      <SHORT-NAME>ICBVC_100ms_Group19_Reserved21_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e583fa6a75913a5cb6eece6f905f767f">
                      <SHORT-NAME>ICBVC_100ms_Group19_Reserved35_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d1d73cff37a3090bc63b31b67d9390e">
                      <SHORT-NAME>ICBVC_100ms_Group19_Reserved58_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="0105dfbd98733417a9a6114d038cd6b1">
                      <SHORT-NAME>ICBVC_100ms_PDU19_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="78f4a0a50a4439708ae70bfbc5c352ba">
                      <SHORT-NAME>ICBVC_500ms_PDU67_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="d27023153dca3a1da013ccafde9674f0">
                      <SHORT-NAME>ICBVC_50ms_Group256_CRC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3f0ea57a225a3470a140993ded1dbb52">
                      <SHORT-NAME>ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="31f2b7a56f1030ec842cad5229d78034">
                      <SHORT-NAME>ICBVC_50ms_Group256_RC_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="980512ba71aa3591b360d7d9efaf49aa">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved100_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="08a6f972195a3d2ea94ecb6f7ff1269a">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved103_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b94555420be7302bae540d6b322d5b1f">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved111_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8919f0b8f060376a9986f7689f8c4103">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved119_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef1c4e1c61b53608aa75dc5787ddff32">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved127_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84eab7ae21b537149a9b7cfd62b05c17">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved85_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c73feab3382333183fb8c2bdb100718">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved95_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2589ea25023b35c1ad6a492c3bf80bfe">
                      <SHORT-NAME>ICBVC_50ms_Group256_Reserved96_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="9621e278539e355dad949ba0d72620e0">
                      <SHORT-NAME>ICBVC_50ms_PDU256_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="04a71bde34af3747bb1cf6ea857dc6e0">
                      <SHORT-NAME>ICBVC_RHBKBCANFD_500ms_FrP67_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="826793fd6d1232debabf643e18afa44a">
                      <SHORT-NAME>ICBVC_RZCUCANFD_100ms_FrP19_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="0a52126720e53a7ab201e7ddf438a737">
                      <SHORT-NAME>ILCActvnDircnDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24a632083ca93d3f98c8754128b2dd86">
                      <SHORT-NAME>ILCActvnVelDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="544400830722320bbf2191d38d7807e0">
                      <SHORT-NAME>ILCSwDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eb260c95723d30498b9ca97d1be6232c">
                      <SHORT-NAME>ILCSysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="f2940db92efc3f4a9901831dd5cea505">
                      <SHORT-NAME>IMCU_PTCANFD_20ms_Container01_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="beedee7f431d3e79bb3323f3821bebfe">
                      <SHORT-NAME>IMCU_SFCANFD_10ms_Container08_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="4642fac687e837cd90c9a7d67635bdc8">
                      <SHORT-NAME>IMU_SN_IMU_SN_IMU_SN_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b48d89b956b939a0925cbc23ecf29328">
                      <SHORT-NAME>IMU_Signal_status_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7c881c647743ef799c54e3dae67a74a">
                      <SHORT-NAME>IPDStsResp_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="6d1c70be8b7939699d8a507954d1a3c6">
                      <SHORT-NAME>IPD_100ms_PDU03_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="381acce2aff93b33b168e0d30ca6b1c2">
                      <SHORT-NAME>IPD_20ms_Group43_CRC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c8bcf41434b31d18fb75a3408f3fa6f">
                      <SHORT-NAME>IPD_20ms_Group43_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1a2c8ede3d334c1ab5872f1725a2e29">
                      <SHORT-NAME>IPD_20ms_Group43_RC_IPD_20ms_Group43_IPD_20ms_Group43_IPD_20ms_Group43_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9c6e211969d736809076d98dd10f8ed3">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3015e60293603322b8436254bb8632c2">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="933b079109db3761b2485643adb429a3">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d757e50ead57359ab04014dc5f408919">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dca5d4b0db333731b33220e830bfff27">
                      <SHORT-NAME>IPD_20ms_Group43_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ea3bbf175d2b334ea97c7ee10585f3af">
                      <SHORT-NAME>IPD_20ms_Group64_CRC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dcd8cecf3cd4327993b265fe23784d8a">
                      <SHORT-NAME>IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d98a76fe4983837825c374c0f0f5c49">
                      <SHORT-NAME>IPD_20ms_Group64_RC_IPD_20ms_Group64_IPD_20ms_Group64_IPD_20ms_Group64_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9bcf8233c8c3c749076ba92f11bfd14">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved10_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a5eec87580c63a209906d846a215fd9d">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d6d8f410346039c2bc9fc8b74573061c">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="566f50d827eb320fa0a3c1f35d5f9763">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18aae4c40298322b863a04cb6b126c90">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13343386ff163172a776b04af453fada">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a100630314738cc892148f1e4af9167">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f14458ae8e5e3e2db47ece8b8ceabcad">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved7_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="57d53548c7c5374e9ba9dd0b98c50b4e">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved8_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1dd3f77295c039c2a3d195b3b2214a79">
                      <SHORT-NAME>IPD_20ms_Group64_Reserved9_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f932cffc20430f3b3926e28f5aa1363">
                      <SHORT-NAME>IPD_20ms_Group67_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b80f62cfeeff3f958fa3408986905c6e">
                      <SHORT-NAME>IPD_20ms_Group67_IPD_20ms_Group67_IPD_20ms_Group67_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc69f6f0a36139ae8dbf78a8585c24cd">
                      <SHORT-NAME>IPD_20ms_Group67_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27af38f244893bbb865eeceeafca7f9e">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved103_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ae8cadcaf5fc35b586faead1a0319fbb">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved111_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="41177048308b3b5493f288426f914b3c">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved119_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="76f63123d06a34d79de92d09169b338d">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved127_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b591f497ee036908fcc713a6f91ab20">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved15_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c98e94a5ebf33ec9cfc2b0d4639b558">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved23_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72b946e0da603215845d311e0777fcb2">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved31_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99375b59316238f5aaac4060a297e144">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved39_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c2188f9d691360db8942b616335f6d5">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved47_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8a227b167403f0d91d796fcce00a92c">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved55_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="92455c219fd535e3905e7e042e334442">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved63_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f93e8cff4ee34a7945ad011f8e1f696">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved71_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7533e17cfe9237dda6b1d764d7151ddd">
                      <SHORT-NAME>IPD_20ms_Group67_Reserved95_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="6d22fd5e29473094a8adacd305b71f54">
                      <SHORT-NAME>IPD_20ms_PDU43_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b8a5384289a938ea8c4230b4d88acf0d">
                      <SHORT-NAME>IPD_20ms_PDU64_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="38fb00040e62390cb9619a3ea617328b">
                      <SHORT-NAME>IPD_20ms_PDU67_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="c877520e6d7a3f34a5119cf3bcf2cba4">
                      <SHORT-NAME>IPD_50ms_Group49_CRC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88356d5f93763dfdb8c9fe76aa8bf865">
                      <SHORT-NAME>IPD_50ms_Group49_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e250018b05f73c32850f452e3c56f67b">
                      <SHORT-NAME>IPD_50ms_Group49_RC_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed0c2cc065fe39d9a5ab81696ea3a516">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved1_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="638071ce250238d2a5751be9e4db65e2">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved2_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e581e2cb219361786be63a294b66285">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved3_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74784ba421c13ff8914ffda367312134">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved4_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="694dd53dff1a30e384510a191f63982d">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved5_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0699275bad503a0d95c9c0b7cbd81ca5">
                      <SHORT-NAME>IPD_50ms_Group49_Reserved6_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="0838a0c4f1ad3963bae8c885aa70c458">
                      <SHORT-NAME>IPD_50ms_PDU49_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="b987fc6af66432578922e63b938bf4fa">
                      <SHORT-NAME>IPD_BKPCANFD_20ms_FrP43_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="49a6d1fd76843597b115dda1c773c6f9">
                      <SHORT-NAME>IPD_BKPCANFD_50ms_FrP49_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="792f1d1549c934bc82e4aa591de5be05">
                      <SHORT-NAME>IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_NKI_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ba389fd2fcb3a89a349fd9abf0b9723">
                      <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_NM_BSMtoRMS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e86f8390d5b0357684fc6508e3a97e96">
                      <SHORT-NAME>IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_NM_NOSSta_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="112131ab3fd83d59bb3965e80f1b7ee1">
                      <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_NM_NOStoRMS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c09f38403971328096616cbfdd761155">
                      <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_NM_PBSMtoRMS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3de458153e9137d4a33ffe1cca99a558">
                      <SHORT-NAME>IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_NM_RMSSta_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2ebe57f00ecd370cacd332126a5119c1">
                      <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_NM_RMStoNOS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="209f894e2a503b5d8f7dc8722ef68c8b">
                      <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_NM_RSStoNOS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6b42e4f7990d39a4aecf35476b3bc99c">
                      <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_NM_RSStoRMS_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b0dfa9bbfe13a9b8cd8c96008e57489">
                      <SHORT-NAME>IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_NOI_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="70d28607f9ed3305adf3ab83f3e153e2">
                      <SHORT-NAME>IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_NWI_PTCANFD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="813357a5c434315ebf87fc7f112f633b">
                      <SHORT-NAME>IPD_PTCANFD_100ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="085c5c999d2c3b048865916621fd2251">
                      <SHORT-NAME>IPD_PTCANFD_20ms_FrP64_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="5f5a256fa9c5321a8e024ec57c820a08">
                      <SHORT-NAME>IPD_PTCANFD_20ms_FrP67_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="748c0a940c1933529510890ded5dab4b">
                      <SHORT-NAME>IPD_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="03f7a0088502349bbcf23b51039fbecc">
                      <SHORT-NAME>IgnOffTimeV_IgnOffTimeV_IgnOffTimeV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52ca1f12780d318b8e3781cf9362a5e4">
                      <SHORT-NAME>IgnOffTime_IgnOffTime_IgnOffTime_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b991b13a7a11344bb4187031b33059e5">
                      <SHORT-NAME>IntlckRelayAuth_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c99b4b24c6793104b87c1f8f40494f49">
                      <SHORT-NAME>KeepPwrRsnIPD_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3be84dda81593970b8e4abd575f37c6c">
                      <SHORT-NAME>LADSAFnInd_IPD_50ms_Group49_IPD_50ms_Group49_IPD_50ms_Group49_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3d05624752e33be9868bc8943d0e6ab3">
                      <SHORT-NAME>LDWAdoWrnngDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d8682952dbe34118f8ca3f03f6e91ae">
                      <SHORT-NAME>LDWLKAAudReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="551070749a9b3454bccc289a103acc60">
                      <SHORT-NAME>LDWLKADspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="83cfb33788533b5ab10dd69ff63a267c">
                      <SHORT-NAME>LDWLKAHptWrnngDspCmd_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="972b6ba4371f396f820c17c95281878b">
                      <SHORT-NAME>LDWSnstvtLvl_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0b8585d555bc33d4ac8d6d09157c7d06">
                      <SHORT-NAME>LKADrvrTkovReq_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2dff959e00ec3282aa7befb913531c75">
                      <SHORT-NAME>LKASysFltSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9eb2f4eb560a38e09fe42779e6ca4ec3">
                      <SHORT-NAME>LKASysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ee887f061b7738ad881fb740526243e7">
                      <SHORT-NAME>LVBMDisChrgMOSCtrl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="fed05d0d4d7333cea815f0af61fb9229">
                      <SHORT-NAME>LVBM_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="c86ed3ca9c5c3dd5ba7571244c7fd4c8">
                      <SHORT-NAME>LVBatChrgReqInhbt_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7346229c374d3ca8afd2754f4051dd70">
                      <SHORT-NAME>LVBatChrgReqRaw_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4fc0267d05653bb2a4725918dc44ad2a">
                      <SHORT-NAME>LVBatEnrgLow_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9482171b826b373fbd3bbb7b89baef8f">
                      <SHORT-NAME>LVBatEnrgSufct_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2819991ca1de3776ade137b28847786b">
                      <SHORT-NAME>LVBatSelfWakeupFlg_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="b38d330c00bb3afaaa3bc41e220e5a20">
                      <SHORT-NAME>MMCU_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="9b466b6c64e53394a2ac310687929157">
                      <SHORT-NAME>MaxAvlblTotWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="49b7745ec1393ae59c558c0b7f7f6653">
                      <SHORT-NAME>MaxAvlblTotWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc7980b8096935e28662a3cb32562320">
                      <SHORT-NAME>MinAvlblTotWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39b6cc9c769f33e7bd389518b65cc310">
                      <SHORT-NAME>MinAvlblTotWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dbff5158bd8b3340b13cbfd51c08fa6b">
                      <SHORT-NAME>NarwSpcAstSwSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="0cf70b5cccd83659bc59dde4c8c52609">
                      <SHORT-NAME>NmPDU_PTCANFD_CCU_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="64e482bfa4043ed3be75be8f566116e4">
                      <SHORT-NAME>NmPDU_PTCANFD_ESS_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c41b372dbb7e3b79adfe586d1c14a4af">
                      <SHORT-NAME>NmPDU_PTCANFD_IPD_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="d0160088cf493bafb75f9146fb718d04">
                      <SHORT-NAME>NmPDU_PTCANFD_LVBM_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="fbecc2a076173c84a1f0d7a4ade40b54">
                      <SHORT-NAME>NmPDU_PTCANFD_MMCU_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="610479c452783130b1990143307eb7e1">
                      <SHORT-NAME>NmPDU_PTCANFD_PEU_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="9260f09c36f93de7b85064633a38900f">
                      <SHORT-NAME>NmPDU_PTCANFD_PICM_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="ae0d74c2c6a63b0f9fc241f390ad8379">
                      <SHORT-NAME>NmPDU_PTCANFD_RZCU_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="f0266bfa75523e5b934487bdf2878a8d">
                      <SHORT-NAME>NmPDU_PTCANFD_SAC_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="0fa4f2f2405b33de927961ae168b1aae">
                      <SHORT-NAME>NmPDU_PTCANFD_ZXD_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="4b6d0e418a6d3458a65354dd4d236569">
                      <SHORT-NAME>OfbdChrgrNgtvSktTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="33f385ce060a3c6eb57c2ded157dcb3c">
                      <SHORT-NAME>OfbdChrgrNgtvSktTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bb307f0d4b833827b42da8b52ad97da7">
                      <SHORT-NAME>OnBdChrgrAltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="94e25faa719a3d8b82cbe78aaeec9dea">
                      <SHORT-NAME>OnBdChrgrAltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="216df6a7fd9535a58cf79afe89d8d0de">
                      <SHORT-NAME>OnBdChrgrCtrlPilotPWMDuty_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1c2d571c6353734ab8e9b48c4694823">
                      <SHORT-NAME>OnBdChrgrCtrlPilotPWMSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4a5212ea02532f4b468c17e4ec21af9">
                      <SHORT-NAME>OnBdChrgrHVILStsValV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2274c11c78a136669a8fb47e3a58ef24">
                      <SHORT-NAME>OnBdChrgrHVILStsVal_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4c26089aab9236e6b3e055b0f7ab2134">
                      <SHORT-NAME>OnBdChrgrL1AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a27ad172ebee377da305292309ad1bfa">
                      <SHORT-NAME>OnBdChrgrL1AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f6266614590c33869814c2b89aef52ac">
                      <SHORT-NAME>OnBdChrgrL2AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89559a3af6213402b682cc2dbba98b02">
                      <SHORT-NAME>OnBdChrgrL2AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2886a74a97cc3f4fb90c31921cb9956d">
                      <SHORT-NAME>OnBdChrgrL3AltrCrntInptCrnt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="440f243e5ef632c49f0663ab929266b1">
                      <SHORT-NAME>OnBdChrgrL3AltrCrntInptVol_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ab7af25b95d3e629e33b43bd7b317b1">
                      <SHORT-NAME>OnBdChrgrLastWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5f3ec49d5ef3e3aba03f1f1ab5c5c4d">
                      <SHORT-NAME>OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_OnBdChrgrOptAltPwr_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="52fd837e1b8734dea81ed3ed7ad0fafd">
                      <SHORT-NAME>OnBdChrgrOtptVolV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87eafad358a0350bb50dfaa9fb7f8da8">
                      <SHORT-NAME>OnBdChrgrSktElecLckStaV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a9d0bd51f71033df9aacd4f25f4fb004">
                      <SHORT-NAME>OnBdChrgrSktElecLckSta_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4ece453d7af7319c8b76e826bebe65d3">
                      <SHORT-NAME>OnBdChrgrSktPstvSnsrTemV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5c02a31ea862313d8a465f5f418918c4">
                      <SHORT-NAME>OnBdChrgrSktPstvSnsrTem_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="27ac1d14575f3e64a81fff90e88fc2be">
                      <SHORT-NAME>OnBdChrgrSts_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca7c6f2a81eb3c0aaedc453f42132af5">
                      <SHORT-NAME>OnBdChrgrWkup_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b78650430013884b3e9d7932eb96a03">
                      <SHORT-NAME>OnbdChrgrAltrCrntInptHVCrntLmt_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a8094a0acdf3394a4b103f42537d528">
                      <SHORT-NAME>OnbdChrgrOpngMd_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f28f96812e4232be88de4c9e046bb59d">
                      <SHORT-NAME>OnbdChrgrOtptCrntV_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4da4ef92733430df97bb49267124ed1d">
                      <SHORT-NAME>OnbdChrgrOtptCrntVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c146bd50405233e5a332fb776023a8d7">
                      <SHORT-NAME>OnbdChrgrOtptVolVal_CCU_100ms_Group07_CCU_100ms_Group07_CCU_100ms_Group07_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77c64ea5bb633a8596ff29494da33edc">
                      <SHORT-NAME>OnbdChrgrSktEleccLckEnable_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3945a257d35b3cbaaadb5d456952e428">
                      <SHORT-NAME>OtsdAirTemPtEstdMsk_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c08b349f3d2f371d970e339f71ec7324">
                      <SHORT-NAME>OtsdAirTemPtEstdV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e44b2ed673ee3592a5ad8adaf668230d">
                      <SHORT-NAME>OtsdAirTemPtEstd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66f4cf7f7f783c82a1a2a14788768615">
                      <SHORT-NAME>PDUHVILStsV_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a0af5c9f17903e8aa7ecf42c71afe855">
                      <SHORT-NAME>PDUHVILSts_CCU_100ms_Group02_CCU_100ms_Group02_CCU_100ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72b45022127a3e04a0c1c17f7cfcb0c5">
                      <SHORT-NAME>PEUMotADampTrqCmdd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6465c0808b4b36e3a7d3a18b1b9ac652">
                      <SHORT-NAME>PEUMotAMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f53d0d2518793a689519a67a885aa617">
                      <SHORT-NAME>PEUMotASpdSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8da621cf3bf931f79256a2ec4d8d8890">
                      <SHORT-NAME>PEUMotASpdV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0a0b08ec9e273550a4d05c48f52e8d7e">
                      <SHORT-NAME>PEUMotASpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b3709cd0f8d3d838daf8b61fa41a792">
                      <SHORT-NAME>PEUMotAToqAchV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="91ff7a10bba93de8bcf2704536d16a95">
                      <SHORT-NAME>PEUMotAToqAch_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6e8a12b92b28379eb56e158b0f1833cc">
                      <SHORT-NAME>PEUMotBDampTrqCmdd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="762e14b33f38354a970173c06ecb7683">
                      <SHORT-NAME>PEUMotBMdAch_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb0b9a880fb03ee58ae52c5e5ab63eb0">
                      <SHORT-NAME>PEUMotBSpdSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aebf744d2eb2319fbc5c180e078b341a">
                      <SHORT-NAME>PEUMotBSpdV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f4f95f1ef68b3a58ad7e8c5953e5c6ff">
                      <SHORT-NAME>PEUMotBSpd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc0c9f5ebdfb39219f9fa1689fd8c30a">
                      <SHORT-NAME>PEUMotBToqAchV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="943d6a4f4e583e7fbac2c960e0e81d06">
                      <SHORT-NAME>PEUMotBToqAch_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5bafcb2979f3e03b7caf483e18d93a9">
                      <SHORT-NAME>PEU_10ms_Group25_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50b0bf38ea773bb29eac4cf262c473bb">
                      <SHORT-NAME>PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ebb79d5d3513353292d7fd9eecd3e0ca">
                      <SHORT-NAME>PEU_10ms_Group25_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f04f4107dba13f76a08a5283cf89dee3">
                      <SHORT-NAME>PEU_10ms_Group25_Reserved147_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d0324c444d73eb4ab80d12ba33ed598">
                      <SHORT-NAME>PEU_10ms_Group25_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e3f470f952539c4908fea58c11238d9">
                      <SHORT-NAME>PEU_10ms_Group25_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="65a2c36e11403ad983a49db077fca655">
                      <SHORT-NAME>PEU_10ms_PDU25_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="86a1a304499836dd9e556cc1421f0c94">
                      <SHORT-NAME>PEU_PTCANFD_10ms_FrP25_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="7162d6be2d0c3b6cb59f15a28cabdf22">
                      <SHORT-NAME>PEU_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="dc775a03637b3544aa19edad6ce5d358">
                      <SHORT-NAME>PICM_100ms_PDU06_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="aa810a2bce613db48c81a3b9fec9e207">
                      <SHORT-NAME>PICM_PTCANFD_100ms_FrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="cd8ab19aa6cf340c96ffa79cef69904b">
                      <SHORT-NAME>PICM_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="a6155a55aefd3108ad1944b584c9b7e7">
                      <SHORT-NAME>PICU_10ms_Group03_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75f1609d5730372bb112dbb7e76f5c4b">
                      <SHORT-NAME>PICU_10ms_Group03_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="065bd02938d935ffa7a2d77bd99c0611">
                      <SHORT-NAME>PICU_10ms_Group03_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dd2e64dd05573753a98687e81df998f6">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a27435d4bbbf36658d345a9f8f1c8a24">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75d4d945d45a3064a96b6f205219e6e8">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="903d3b12bc313c2d8f5080b91744153a">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="964580984fbf3f42b190b980bc1f6d96">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="627acabf375c31a5b0c92748f8c71991">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0131f5ac12e6365fb9242de27bc91949">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="647734ff47a1301e9d549ef30d33d88c">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved8_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="347890362b383884aab8c72a89ee1c92">
                      <SHORT-NAME>PICU_10ms_Group03_Reserved9_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c7909df6edc3234bf51a2fdc6ee9d6c">
                      <SHORT-NAME>PICU_10ms_Group23_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f84ce86cbbfa33cd8d073960e14fa366">
                      <SHORT-NAME>PICU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f583f5b527923974a0c14070344a27fe">
                      <SHORT-NAME>PICU_10ms_Group23_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="158373a41f3e3818bbab5cd891f492da">
                      <SHORT-NAME>PICU_10ms_Group23_Reserved18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="349dc44575583a6ca20cea45c77eed20">
                      <SHORT-NAME>PICU_10ms_PDU03_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="16d1a13c988d3b10b90359244b8a1b74">
                      <SHORT-NAME>PICU_10ms_PDU23_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="98c6aba459813c3a8d394fb9800a8c8a">
                      <SHORT-NAME>PICU_20ms_Group11_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89844c130ef23493bef778c80b747152">
                      <SHORT-NAME>PICU_20ms_Group11_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b2d42d055893c2c931da32b71068709">
                      <SHORT-NAME>PICU_20ms_Group11_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c62ea42021c2352ea1959e2b426bf092">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b33e26d6546312691c4d23ebc09f83a">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18f81469d7d7322cb56d6d5f3ba3ff87">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="931d2bcf599830dc947d3e56ae12e5c0">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7214aabb91d639918f833b6ca8c43f3a">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b170a35a8b57369f9788902403f2b2be">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3bd8937f23f33a4faf11bbd04d92b478">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="523fb9a9047235f184591538b8810efe">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved8_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13e749f2a31033d38ca4fe08a8c5bf27">
                      <SHORT-NAME>PICU_20ms_Group11_Reserved9_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="ee8abe0cb572301691a90cbc634d3148">
                      <SHORT-NAME>PICU_20ms_PDU11_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="b3592407ed9e3929b9fafef8381964c8">
                      <SHORT-NAME>PICU_PTCANFD_10ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="cf537da1bc8b301a93a222806ecf6ee0">
                      <SHORT-NAME>PICU_PTCANFD_20ms_FrP11_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="90585bdde8423ca4b84ba8a99944bfbc">
                      <SHORT-NAME>PICU_PTEXTDCAN_10ms_FrP23_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="9335988bd0f63676b51b2373cb4cbd8e">
                      <SHORT-NAME>PMDCSta_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="240296e3c89a3455afced65e6fed379f">
                      <SHORT-NAME>PropSysA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ffc40777b9953fd88e8fbfe5dfe5d6a5">
                      <SHORT-NAME>PtACCA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d3d44f425573f2082a81e4cc85d9761">
                      <SHORT-NAME>PtACCToqReqResp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="abb19f5b86fd3a9abc4909a5800f2694">
                      <SHORT-NAME>PtAPASts_RZCU_10ms_Group24_RZCU_10ms_Group24_RZCU_10ms_Group24_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1927272337b53c4fbefa1e319361d3e7">
                      <SHORT-NAME>PtAPAToqReqResp_RZCU_10ms_Group23_RZCU_10ms_Group23_RZCU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54126d6dab483c5b940baa33de404013">
                      <SHORT-NAME>PtHVCntarReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3983d8dd730638b88d8159ee0e30e978">
                      <SHORT-NAME>RVSEPTRdy_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f404cfd0c1153bbb979f610652ef27de">
                      <SHORT-NAME>RVSEnRunning_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="da3c263c4b6c3d56878932e06413762d">
                      <SHORT-NAME>RVSPtCrkAbotd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1a1b95610f4139f685998c3521db49c0">
                      <SHORT-NAME>RVSPtRunAbotd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c30b8ab0ddb3db2bd56d1e1b66d39fd">
                      <SHORT-NAME>RZCUIgnDiagSts_RZCUIgnDiagSts_RZCUIgnDiagSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="901716e8ac043f7e80b772d62338c8d1">
                      <SHORT-NAME>RZCUIgnSts_RZCUIgnSts_RZCUIgnSts_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="eaab28a4e72537a7b968d76391c5c2be">
                      <SHORT-NAME>RZCU_1000ms_PDU67_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="70368671a9103b24b52f0423fa27713e">
                      <SHORT-NAME>RZCU_100ms_Group10_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="851610d4ce26396684bbbea96aca0d38">
                      <SHORT-NAME>RZCU_100ms_Group10_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="759f2b6187ec39c4b450b1b74815a88e">
                      <SHORT-NAME>RZCU_100ms_Group10_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f06b6aa2d2f234bf84a3540439a9b788">
                      <SHORT-NAME>RZCU_100ms_Group10_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1897b1076372386baefa3c57dee112fc">
                      <SHORT-NAME>RZCU_100ms_Group10_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2108650504f13017a2b0fa2b5b39727d">
                      <SHORT-NAME>RZCU_100ms_Group10_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0d92cba113132c28e62017d512f877f">
                      <SHORT-NAME>RZCU_100ms_Group10_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1a714d391cf43d66a05541e333eb8e03">
                      <SHORT-NAME>RZCU_100ms_Group10_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="b1cc8af330ad37df9266e44538e05021">
                      <SHORT-NAME>RZCU_100ms_PDU10_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="845763bdeeda3f098b368def8fec34d8">
                      <SHORT-NAME>RZCU_10ms_Group01_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c1c7745ee557380c8870f237cdf5860d">
                      <SHORT-NAME>RZCU_10ms_Group01_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a140abe3ee734d5b044d191fd1e86f6">
                      <SHORT-NAME>RZCU_10ms_Group01_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c57debd3d42e3d84914bccd3024de409">
                      <SHORT-NAME>RZCU_10ms_Group01_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2e75f1f3d86313689bf255d16c1441d">
                      <SHORT-NAME>RZCU_10ms_Group01_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="853e48d1dc253fd2b2652601d2c74e39">
                      <SHORT-NAME>RZCU_10ms_Group01_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8cb14171c6703b56a67208b3cb8a0142">
                      <SHORT-NAME>RZCU_10ms_Group02_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b45ff8b72ecf32a388d8ce4fc9b4dfc0">
                      <SHORT-NAME>RZCU_10ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ff81c42b0d683e31a8de8d15dc9d08f8">
                      <SHORT-NAME>RZCU_10ms_Group02_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7ee8f4ece4d3486b30e3650a2dac809">
                      <SHORT-NAME>RZCU_10ms_Group02_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c85bf36b044b3187b47af8a5995d4cd0">
                      <SHORT-NAME>RZCU_10ms_Group22_CRC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef8affa49fea37189bdf2e39aa13621d">
                      <SHORT-NAME>RZCU_10ms_Group22_RC_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b27675c9c1b35a58bbb12601491d720">
                      <SHORT-NAME>RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4705a8103be63776b29a3de9a828514d">
                      <SHORT-NAME>RZCU_10ms_Group22_Reserved47_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="392328af39bd36299b1d370ac5fd504a">
                      <SHORT-NAME>RZCU_10ms_Group22_Reserved95_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7fc4efb911b43f0a88b4f007c27cea60">
                      <SHORT-NAME>RZCU_10ms_Group23_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aba8a7de5c563e679017b2172801cbf4">
                      <SHORT-NAME>RZCU_10ms_Group23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="338277d2987336469a4152d2be7843fe">
                      <SHORT-NAME>RZCU_10ms_Group23_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="842a53b4b69d379e89bd662a5138c601">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved10_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="924cc8ca8194334da0235f4415878b0f">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved11_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="32752ce030b23e608ce3c1544b13866e">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved12_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3cafac595983ac4bd1c993889e743ae">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved13_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="631b967666a13117b3bf5bcaff36a189">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved14_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="239f709fc1c931e0af8846cf8635bbb5">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved15_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2c6e53f65a6f3d8ca8b5ab4b64d3911f">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9d4895e7933a333ab311d246c00e71a1">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b3b47932061639de9cf3f52c31f5e205">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="312dfa0eb72e3dc1adb3890200bbdc88">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ba993656b7739c78086bb36255fcd6e">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="61956ffeccd23446b5f48a723cb544e0">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="30b43bc60c8239b997b2058ad0ea6c54">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved7_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="af7d0f73c6f03b799a3e38248a58e9ee">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved8_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="78667deccd7f399e8e42e36f559e5761">
                      <SHORT-NAME>RZCU_10ms_Group23_Reserved9_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1b04fb7c2ccc39fea4f28ded248c5caa">
                      <SHORT-NAME>RZCU_10ms_Group24_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="201a634edaae37b1b92f06f6ebcaed2c">
                      <SHORT-NAME>RZCU_10ms_Group24_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="36aff11c99423719ab7c5066cea07abf">
                      <SHORT-NAME>RZCU_10ms_Group24_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="19d0d77653b93317baf4407406eca758">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="141662c014343a0d8f657ad2ee7bd0c1">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c6ec913723a93b65a2f356db9612c570">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6e00afbdf2893a35b661b89c4b050755">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db24996ff6d23e36a3f7bcb76da4711f">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed74c1adf7bc3133b5b0781e29b358d6">
                      <SHORT-NAME>RZCU_10ms_Group24_Reserved6_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8fb8c4d284393a1eb549eeaa8291b1ae">
                      <SHORT-NAME>RZCU_10ms_Group90_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="038ed2deb13c303b8167f0cf3877c07d">
                      <SHORT-NAME>RZCU_10ms_Group90_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fe9d90c3f41a3045a9672dd499bba953">
                      <SHORT-NAME>RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="956b250e1b873c0095951e27086c4926">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved103_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6fffaa26b86d3a49b7b19d4ff240d9e9">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved111_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="70a63a32fbbb34b3ad8b8ed934ea73c3">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved119_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c89b65301d73281bcb79da4caa73475">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved127_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f8a30109776138df899dbc67fb09c956">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved135_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="753d370a6f4335a0ae4257a78422a695">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved143_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e40cc3a1f1fe3b4bb5588ae4904a7faf">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved151_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a5b7c7663923fb88e7a6532b5f104dd">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved159_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cdb5e81993223991987055945463c6f0">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved15_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7087225ed1c433149086fad6fd654c14">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved23_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2bb5523f662931dda58cb6fedb78d0e3">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved31_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7588d4a068a3d4f948426af857a4bba">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved39_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="dc8fabab692b35a6a9e1fe52b3d3e78f">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved47_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="65cdd905efef3a24987688e4661065f0">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved55_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2047bca62e343687ad1d2ae0c10957cb">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved63_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="143e804d813d34fca4e932d299abf900">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved71_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9335e70e77b63aa1ae89c8437d39b870">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved79_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cde80bd40d4435028101b2e03da085e6">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved83_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a6c3b61e1233c47b71a91253368724f">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved87_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7c3e78e374d33958a255a8b34e34d423">
                      <SHORT-NAME>RZCU_10ms_Group90_Reserved95_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="8f909b408356395a9076068817a5c159">
                      <SHORT-NAME>RZCU_10ms_PDU01_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="9feb7926831335c1861b94f19df32b65">
                      <SHORT-NAME>RZCU_10ms_PDU02_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1cbc4536ad5a3eee867b70dd1fd77fb5">
                      <SHORT-NAME>RZCU_10ms_PDU22_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="1972a7b0ee073110a028ad797b400df5">
                      <SHORT-NAME>RZCU_10ms_PDU23_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="b4ab065f97923824a47d7128a1c08310">
                      <SHORT-NAME>RZCU_10ms_PDU24_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c9da106ff1b93b69b87db987ae7e1dd8">
                      <SHORT-NAME>RZCU_10ms_PDU90_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="7429e4e9772836c387d970cff82fb8a1">
                      <SHORT-NAME>RZCU_20ms_Group06_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9cf06df130ce399183c0c974acf0133e">
                      <SHORT-NAME>RZCU_20ms_Group06_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="db4bd7efed6e391aa1a1ab660f39fa9c">
                      <SHORT-NAME>RZCU_20ms_Group06_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3cac2104b9683606abb8f7217cc4bc8e">
                      <SHORT-NAME>RZCU_20ms_Group06_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e9e595856b23f29b853b848735b12b5">
                      <SHORT-NAME>RZCU_20ms_Group06_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3362932004c432dc8acfc5dad4dea34a">
                      <SHORT-NAME>RZCU_20ms_Group06_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="68fa0e72b7583ac495fa2ae8931c5af9">
                      <SHORT-NAME>RZCU_20ms_Group06_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6228c6b490ff35a78faa8f425933a0c0">
                      <SHORT-NAME>RZCU_20ms_Group06_Reserved5_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="2d5609cbedc5309f89916dd86d6122c6">
                      <SHORT-NAME>RZCU_20ms_PDU06_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="8f838caa428237c4b69d2a4b20c84056">
                      <SHORT-NAME>RZCU_50ms_PDU25_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="895af023c1303382b435944bfbd9da2f">
                      <SHORT-NAME>RZCU_PTCANFD_100ms_FrP10_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="76951ca6d70d32adb4e9548057c94e9d">
                      <SHORT-NAME>RZCU_PTCANFD_10ms_FrP90_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b271c96855053c5797385e5f51fc705e">
                      <SHORT-NAME>RZCU_PTCANFD_20ms_ConFrP06_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="044579aaf3053e0f9c1dd9c7e7cb2f11">
                      <SHORT-NAME>RZCU_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="c62feb150fc73eeb98d6843de1671d08">
                      <SHORT-NAME>RZCU_RZCUCANFD_1000ms_FrP67_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f9ba8fbe75f8357fa2997b2950f2efc3">
                      <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP22_NoSecOC_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="832a01c75e9135ff9b032c0127bde016">
                      <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP23_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="f36ac5e33fd731c69a378e664d8f646c">
                      <SHORT-NAME>RZCU_RZCUCANFD_10ms_FrP24_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="9d0af7664b213a93acce5701420fb4e1">
                      <SHORT-NAME>RZCU_RZCUCANFD_50ms_FrP25_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="51ec8f6bf45c323ab17aaecd4547e77b">
                      <SHORT-NAME>RZCU_SFCANFD_10ms_ConFrP08_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="b64cad85c0b233c7883cba1c9474e844">
                      <SHORT-NAME>RdundtHybCmddEnToqImmd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9a5a65d26ff8347d88d77daaf5451c87">
                      <SHORT-NAME>RdundtHybCmddEnToqPrdtd_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66c78fa1f5f73d7d9e44ff56df14c68a">
                      <SHORT-NAME>RdundtHybCmddEnToqRespTyp_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04206b5a46c7343ebb22593cba26376b">
                      <SHORT-NAME>ReAxleMaxAvlblWhlDrvTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="77f84203d73d3036bfc9941f66c3688a">
                      <SHORT-NAME>ReAxleMaxAvlblWhlDrvTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6d31501300d3b2599c196c0a5932a20">
                      <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTqV_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="de7cd52b28d331f7877416d5a7126457">
                      <SHORT-NAME>ReAxleMaxAvlblWhlRgtnTq_PEU_10ms_Group25_PEU_10ms_Group25_PEU_10ms_Group25_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74abeda2cba437589a30601446af89c9">
                      <SHORT-NAME>RgnLvReqFICMV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="95cd74426dc4353fb842027c011ae2db">
                      <SHORT-NAME>RgnLvReqFICM_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="895313065d3f3c07b9cd988c902a1a1e">
                      <SHORT-NAME>RoadCrvtDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="633cdc738d5a3368822ae10cd2b1b3b8">
                      <SHORT-NAME>RoadCrvt_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9fe980e0a5837c6a48dff07b8364c8c">
                      <SHORT-NAME>RoadSlopeDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d101fae720d34329b60eb26195f272d">
                      <SHORT-NAME>RoadSlope_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4e6e6fee003a33319deecec939ec8257">
                      <SHORT-NAME>RoughRoaddetectionDist_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3cae0d17a810304fa07854e2dc71c554">
                      <SHORT-NAME>RoughRoaddetection_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2506f2552086388b82e675ffe411b8cc">
                      <SHORT-NAME>RrAxleActuWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b9011fcc52d3e7b992d4e238dbd5cb2">
                      <SHORT-NAME>RrAxleActuWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="271974f6309133c8ace5a8f366dee309">
                      <SHORT-NAME>SAC_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="49714c48b86d34c584f59d464835da0d">
                      <SHORT-NAME>SCUAPAUnderCtrlA_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed9eb5aa3f603ec6bbe541a5dd858a8f">
                      <SHORT-NAME>SCUDrvrIntrvnA_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c0429f23f6ad30a489f2ab2236c86b0d">
                      <SHORT-NAME>SDM_20ms_Group03_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1920cfbb3dc131b58aa7a7e5dd677c1e">
                      <SHORT-NAME>SDM_20ms_Group03_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8200fc97a613f63b9782eae2b0a7e01">
                      <SHORT-NAME>SDM_20ms_Group03_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2328cd4caa3352ebe54b12212036f7a">
                      <SHORT-NAME>SDM_20ms_Group03_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f6a49872a4d3f1abdeb904617ec1a00">
                      <SHORT-NAME>SDM_20ms_Group03_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18697d1dd51b373d93e9bd0534753eed">
                      <SHORT-NAME>SDM_20ms_Group03_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b436524ad8bc36f8a094f8d3bd1cf0ca">
                      <SHORT-NAME>SDM_20ms_Group03_Reserved4_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="f841b49db6193cd996c4c1de6fad4198">
                      <SHORT-NAME>SDM_20ms_PDU03_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="30a9c40df5793d01a9d64d68d14ec8f9">
                      <SHORT-NAME>SDM_CHCANFD_20ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="ca0ea871553330158cc3876a5edb9d17">
                      <SHORT-NAME>SWSCnfmSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e039dd5e551a37bc8d0b930f63e17066">
                      <SHORT-NAME>SWSLFnChngSwA_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f1a6b2a5fd923603b9a5808d7f29fa3c">
                      <SHORT-NAME>SWSPB1SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2753bf86eca635e29d3747363b8abb17">
                      <SHORT-NAME>SWSPB2SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="43a62abade883a959d006dad5859982a">
                      <SHORT-NAME>SWSPB3SwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fdf5476180143edf9984bf9250c76364">
                      <SHORT-NAME>SWSSelLSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="86b94ffc4aac36edb5889580b2a54cfb">
                      <SHORT-NAME>SWSSelRSwStuckL_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="894f03621b423e46a33700d6039f7abe">
                      <SHORT-NAME>SysPwrMdCtrl_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9fc5ce58a24b3c18b4de1206946476ba">
                      <SHORT-NAME>TCM_020ms_PDU18_CRC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="df70eafbb3e73464bb6daf5173b398a0">
                      <SHORT-NAME>TCM_020ms_PDU18_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="e0ba6123bf293c05b1733b1f2e444b4e">
                      <SHORT-NAME>TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e0b6925d117f331c8a58b800d431bf7b">
                      <SHORT-NAME>TCM_020ms_PDU18_RC_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="afe65c166a5233debd61a01cd97bd2fa">
                      <SHORT-NAME>TCM_020ms_PDU18_Reserve01_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fdd65407620e3f5cb15c6d76e5698c7e">
                      <SHORT-NAME>TCM_020ms_PDU18_Reserve02_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a300d0898d253689ab9e45f5ab31f3de">
                      <SHORT-NAME>TCM_020ms_PDU18_Reserve03_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3b3d4ecb2943d11bdb48f39471ba12b">
                      <SHORT-NAME>TCM_025ms_Group02_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2b8eded6fce33f04b8a34ca7c119e3a8">
                      <SHORT-NAME>TCM_025ms_Group02_Reserved1_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="411ded36ad4433729b4b47ac1fb943b3">
                      <SHORT-NAME>TCM_025ms_Group02_Reserved2_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4de3e088bef03ef3aab938446dfdb1fc">
                      <SHORT-NAME>TCM_025ms_Group02_Reserved3_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b6c19b5152a3b599902992ec6ac8469">
                      <SHORT-NAME>TCM_025ms_PDU02_CRC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="86c4b4e451db3630a72898006ddafe1c">
                      <SHORT-NAME>TCM_025ms_PDU02_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="5bd8b679d3ec3c48852127d0011ff37c">
                      <SHORT-NAME>TCM_025ms_PDU02_RC_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a5f24e68dae23be3a652bbb42d9bab3e">
                      <SHORT-NAME>TCM_025ms_PDU05_CRC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="18af07bc6f693bb58ec70e9e8a3a0c64">
                      <SHORT-NAME>TCM_025ms_PDU05_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="5a8802d578123822a5d23f1eecbcdf57">
                      <SHORT-NAME>TCM_025ms_PDU05_RC_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f80c4bef7363fa3b2e7d7d06c0ad135">
                      <SHORT-NAME>TCM_025ms_PDU05_Reserve01_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4b665b7fac8a3f019a64801c70ec5998">
                      <SHORT-NAME>TCM_025ms_PDU20_CRC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="92e2f11006c43426b18fbf7dca48d123">
                      <SHORT-NAME>TCM_025ms_PDU20_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="2a2a3ea6ec0b3210a1000adc5d79bda8">
                      <SHORT-NAME>TCM_025ms_PDU20_RC_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b7c0ab67b0836ffa6073aaa00550a8c">
                      <SHORT-NAME>TCM_025ms_PDU20_Reserve01_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="671943e33e4a346cb400563f22539d05">
                      <SHORT-NAME>TCM_025ms_PDU20_Reserve02_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d719981f77ef384ea1863e69cc1830b4">
                      <SHORT-NAME>TCM_025ms_PDU20_Reserve03_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3ba34e724807388f83ee294bb3cb0696">
                      <SHORT-NAME>TCM_025ms_PDU20_Reserve04_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="85902f3519d6342ea538fc9f4fdf2286">
                      <SHORT-NAME>TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="2062b2962e403b18976e1bcaec45666b">
                      <SHORT-NAME>TCM_PTCAN_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="b1aeaf44f27735d982e538e0ceb257da">
                      <SHORT-NAME>TCM_PTCAN_FrP05_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="b149743ade033af3a66c27c57816f97d">
                      <SHORT-NAME>TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="fe46ac4beec33918908a96f4411dddb8">
                      <SHORT-NAME>TCM_PTEXTCAN2_FrP18_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="26638b9d30853dbb930c8ef7eb36b0ad">
                      <SHORT-NAME>TCM_PTEXTCAN2_FrP20_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="b57591f176b43f2fbea35e5ea49341a8">
                      <SHORT-NAME>TC_IMCU_50ms_PDU28_IPD_PTCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="cc285b1b2aec3a7381e946c1bc6d2aec">
                      <SHORT-NAME>TC_IMCU_ERCANFD_50ms_FrP28_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="f7e30b05376936e3afc71beac3b7ce85">
                      <SHORT-NAME>TJAICASysFltSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="72a544ab3e633a62a95a6d702721a118">
                      <SHORT-NAME>TJAICASysSts_IPD_PTCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5a9fcc17aed33714bd73e5b9b21c042e">
                      <SHORT-NAME>TotActuWhlToqV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="708b27c49ae932a884fab7abd287d7de">
                      <SHORT-NAME>TotActuWhlToq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b438f96b1f6d32bebef5b3da6ec457e1">
                      <SHORT-NAME>TrACCToqReqResp_TCM_025ms_PDU20_TCM_025ms_PDU20_TCM_025ms_PDU20_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a187d32efc83192b23cf5b7c564e12f">
                      <SHORT-NAME>TrAPACanclReq_TCM_020ms_PDU18_TCM_020ms_PDU18_TCM_020ms_PDU18_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="816a86107e7b34deb7cc63e8921eca64">
                      <SHORT-NAME>TrClThrmlProtnNotfn_ECM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6025d25ceba6358f9d81bd268e9ba791">
                      <SHORT-NAME>TrCrkshftToqLdV_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="444c6336cf053a2baf309f301f07b485">
                      <SHORT-NAME>TrCrkshftToqLd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0f41eebc9310349885225d3f0967e79c">
                      <SHORT-NAME>TrCrpMdA_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b867917e906f31d3a609d477bc0fd911">
                      <SHORT-NAME>TrCustSetngDspCmd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="058df52b356b3cc9a026c3d73093749b">
                      <SHORT-NAME>TrEPBAppReq_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e7e49e01d2503ca6a33c66ad57ed9ea9">
                      <SHORT-NAME>TrEnASSOvrd_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca413e4032a936bfba69709f03a52d09">
                      <SHORT-NAME>TrEngdStaV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e5ec03b43a033a46a9ca793eb152d77a">
                      <SHORT-NAME>TrEngdStaV_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7d599bd06b7a3634ae14befa7751559c">
                      <SHORT-NAME>TrEngdSta_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="84696fb6352c3b2c99cd42352fa916f2">
                      <SHORT-NAME>TrEngdSta_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74c7a35f03ff32d9822aeeb3a242a904">
                      <SHORT-NAME>TrEstdGearV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f586abf249303d229330a1bf39f9618a">
                      <SHORT-NAME>TrEstdGearV_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d827b9cc8e3377f8681490e3fde1a91">
                      <SHORT-NAME>TrEstdGear_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8d96f79f151c3af797c03f36b786d21a">
                      <SHORT-NAME>TrEstdGear_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ca40785c94d33841bb2fb42f7ac6aad1">
                      <SHORT-NAME>TrGearV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a8ff3f400c313ce5b07e5d31a86bd421">
                      <SHORT-NAME>TrGear_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a2fd5ac7ff1379ca4d1578e45c8e157">
                      <SHORT-NAME>TrImmdCrkshftToqReqVal_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="64665f970295325bb583ccc8f1585eb5">
                      <SHORT-NAME>TrImmdCrkshftToqRespTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c95b74bf2d113792a392fce55a61e4cd">
                      <SHORT-NAME>TrInptClStsV_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="499144be5fd3302993f115f7e87e1205">
                      <SHORT-NAME>TrInptClSts_ICE_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b206e3530f031d9acbecf22079ee432">
                      <SHORT-NAME>TrIntnlSwPosV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="637187b8c7c83b21a54feea61844538d">
                      <SHORT-NAME>TrIntnlSwPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef7ce1d8ceaf3df29193acd787747490">
                      <SHORT-NAME>TrMinVolReq_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0dec9e96df573043b034c1173ce6a92a">
                      <SHORT-NAME>TrPrdtdCrkshftToqIntrvnTyp_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c94aea4956583ed7a1c5a8adcb9abf3c">
                      <SHORT-NAME>TrPrdtdCrkshftToqReqV_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_TCM_PTCAN_FrP05_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c626dce256ea370688e1a109429cb8be">
                      <SHORT-NAME>TrPrkPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2f24cadeac3031d8845abe6a5e7106d9">
                      <SHORT-NAME>TrPrkSysF_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="39c8887bd9e53319a49755748c6b7ed8">
                      <SHORT-NAME>TrRngInhSts_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="37da0a0483b23868b0533db4a235f395">
                      <SHORT-NAME>TrShftLvrPosV_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24335caba17e3ffa8159a7be76f0e364">
                      <SHORT-NAME>TrShftLvrPosV_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="feed78c15c8c3212815454d1f181ec51">
                      <SHORT-NAME>TrShftLvrPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7be6c7c9137b3889ad142c5dc68ff94a">
                      <SHORT-NAME>TrShftLvrPos_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a419ddb09a3930c2a257c73c4fcabfb1">
                      <SHORT-NAME>TrShftPtrnASts_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="449423f144393e6b9c4ad1474d7317c1">
                      <SHORT-NAME>TrTapUpTapDwnMdSts_TCM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="080ee4a3dd5838acad180facb3fa1152">
                      <SHORT-NAME>TrTrgtShftLvrPos_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7450dccdc31d3b9998766e70933062c4">
                      <SHORT-NAME>TrWrnngDsp_ECM_25ms_Group36_ECM_25ms_Group36_ECM_25ms_Group36_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="485e188cf34838f2a1ec96c83646f97e">
                      <SHORT-NAME>VCUAPAFltRsn_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a07a7a69a2233954bfeb5ca89bcc6009">
                      <SHORT-NAME>VCUAPAUnderCtrlA_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cb6691c5d6113ab7bf55efdfc82d4b2e">
                      <SHORT-NAME>VCUCtrlS2Req_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bdb5194cd0da3faab6e2c37687e49bbc">
                      <SHORT-NAME>VCU_ISAOvSpdOvRd_RZCU_10ms_Group90_RZCU_10ms_Group90_RZCU_10ms_Group90_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="acf064e4aad83cb3ac7909dacf9d196e">
                      <SHORT-NAME>VMCTarReWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="056463a022b53ef8b1c139231cfe4710">
                      <SHORT-NAME>VMCTarReWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b95e25d3dbc83b6ea1fc3ec6b935d9c2">
                      <SHORT-NAME>VMCTarWhlTqMaxLmtV_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c206361a9a963c64b54d2d080fd5f2f5">
                      <SHORT-NAME>VMCTarWhlTqMaxLmt_RZCU_10ms_Group22_RZCU_10ms_Group22_RZCU_10ms_Group22_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="82bcdd35bf84351ab1766ba4c0120a8b">
                      <SHORT-NAME>VSELatAccV_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="668016b1053e3eec94e046a966f972df">
                      <SHORT-NAME>VSELatAcc_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba08b3b44a37304a9ebe88f74009d380">
                      <SHORT-NAME>VSELongtAccV_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="67481959d7323e25a1ae2b3a94ca368e">
                      <SHORT-NAME>VSELongtAcc_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8c04bb8c2b5535609463a8bf4dd217d1">
                      <SHORT-NAME>VehDynYawRateV_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d9d1c03d06e341ea1a190cb787854b6">
                      <SHORT-NAME>VehDynYawRate_SDM_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13dbdb05dd433ec4a6ddb19747572b00">
                      <SHORT-NAME>VehEnrgRdyLvlV_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b9304a45b6b43ed5aa62cf5d526a22e5">
                      <SHORT-NAME>VehEnrgRdyLvl_ICBVC_100ms_Group19_ICBVC_100ms_Group19_ICBVC_100ms_Group19_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="13c5278529d739748592a5d773d67cda">
                      <SHORT-NAME>VehboardSetting_ICBVC_50ms_Group256_ICBVC_50ms_Group256_ICBVC_50ms_Group256_IPD_PTCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="b20ec6df15a0320686e5fad414c84786">
                      <SHORT-NAME>ZXD_BKBCANFD_50ms_FrP256_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="3c33ffac14f63c209696eca0730b1dce">
                      <SHORT-NAME>ZXD_PTCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                  </ECU-COMM-PORT-INSTANCES>
                </CAN-COMMUNICATION-CONNECTOR>
                <CAN-COMMUNICATION-CONNECTOR UUID="Oa505a3f19f25843c4b3c6f0fxOa505a3f19f25843c4b3c6f6700">
                  <SHORT-NAME>IPD_SFCANFD</SHORT-NAME>
                  <COMM-CONTROLLER-REF DEST="CAN-COMMUNICATION-CONTROLLER">/Topology/HardwareComponents/IPD/IPD_SFCANFD1</COMM-CONTROLLER-REF>
                  <ECU-COMM-PORT-INSTANCES>
                    <I-SIGNAL-PORT UUID="f9d8905e7648330eb63324c3c5acca63">
                      <SHORT-NAME>AirbagDplForeCall_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c84fd7afd975318b8f6d5bca9827bb64">
                      <SHORT-NAME>AirbagDplInvsn_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="438312c60d663afd9732a8970f237db7">
                      <SHORT-NAME>AirbagDplInvsneForeCall_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d58f32bc87583e6e920509afc7bba907">
                      <SHORT-NAME>AirbagDpl_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8f05ad671ed73e8094412c0149fd2cea">
                      <SHORT-NAME>AirbagSysFltForeCall_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a1d90f78bd8839439abfdd5d1e628b90">
                      <SHORT-NAME>AirbagSysFltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5fd844c677fc3acdbc4f38e73c9ea191">
                      <SHORT-NAME>AirbagSysFlt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="56247abf40e235f587a7fcaf4cc79a48">
                      <SHORT-NAME>BrkLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8df9948d1e5f372583ac8fcd09758b1b">
                      <SHORT-NAME>BrkLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f2c15abec6dd36738809a54ec97fcde3">
                      <SHORT-NAME>ChrgPwrReq_kW_ChrgPwrReq_kW_ChrgPwrReq_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="18839b6a2b9a3654bee4548b93f9646c">
                      <SHORT-NAME>ChrgReq_flg_ChrgReq_flg_ChrgReq_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5b300587744f3dc0a531d9505573f105">
                      <SHORT-NAME>DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_DFC_Current_DisplyBuffer_0_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="44771a45f4783b0392537aa2a4e9b65d">
                      <SHORT-NAME>DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_DFC_Current_DisplyBuffer_1_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e030c0bb38bf378eb70bef2595efc264">
                      <SHORT-NAME>DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_DFC_Current_DisplyBuffer_2_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="80a7a21ef21e33f2a99041720093ad69">
                      <SHORT-NAME>DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_DrvTqReqWhlFilt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6a0386800a731be84c7ad3618f2560d">
                      <SHORT-NAME>DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_DrvTqReqWhlRawCap_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bd15ef13cd3f356fa2e86a691f3ab3d4">
                      <SHORT-NAME>DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_DrvTqReqWhlRaw_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5cfa2cad56a33b718e405cff7ddbddcc">
                      <SHORT-NAME>DrvrSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4579be9348373ec89490042e79cddfe7">
                      <SHORT-NAME>DrvrSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ede8a6acbe736af84668edd5c1bb638">
                      <SHORT-NAME>DsblICE_flg_DsblICE_flg_DsblICE_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="40f9a6510b603aaa8f68fd289a4c5b41">
                      <SHORT-NAME>DsblISG_flg_DsblISG_flg_DsblISG_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a2332b3fc4e3d40900eeb2b6605090a">
                      <SHORT-NAME>ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_ERCBrkRgnPwrLmt_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ab73f289806031278eb17c2599b9325d">
                      <SHORT-NAME>ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_ERCChrgPwrLmtPeak_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ba880960be1a3ce1b7e7ca5a0c53a236">
                      <SHORT-NAME>ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_ERCChrgPwrLmtWhl_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="86defa058d403f758e664ab8a8103054">
                      <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_ERCDsChrgPwrLmtPeak_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2783c7e9125836d5a1449d02632ac5a0">
                      <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_ERCDsChrgPwrLmtWhl_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50451b232f6f3050aa498ca066808532">
                      <SHORT-NAME>ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_ERCEmgcyPwrDwn_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a169cc3de493e0f8c1bf2b91c371cbd">
                      <SHORT-NAME>ERCFCOReq_flg_ERCFCOReq_flg_ERCFCOReq_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4cc260b881083e38aab6d528319c47c1">
                      <SHORT-NAME>ERCHVAllwd_flg_ERCHVAllwd_flg_ERCHVAllwd_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8335203f35f6362a80d1d0a9414a7428">
                      <SHORT-NAME>ERCHVHldReq_flg_ERCHVHldReq_flg_ERCHVHldReq_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="00406b8379763fb581b8dd7ea18e3465">
                      <SHORT-NAME>ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_ERCMaxChrgPwrLmt_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="baead103be493d0381061f967fe954a1">
                      <SHORT-NAME>ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_ERCMaxDschgPwrLmt_kW_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a21143c27ec032d2a52f4bc4be4f3ab3">
                      <SHORT-NAME>EVMd_flg_EVMd_flg_EVMd_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a7f8e2428edd3a4495c2d62fbd302d28">
                      <SHORT-NAME>EngBrkTqMax_Nm_EngBrkTqMax_Nm_EngBrkTqMax_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="90a670f599c53aa590c45adf33a806f4">
                      <SHORT-NAME>EngFastTqReq_Nm_EngFastTqReq_Nm_EngFastTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7b6dfa4b25a730e4ad953630eeffda6b">
                      <SHORT-NAME>EngFastTqTypReq_enum_EngFastTqTypReq_enum_EngFastTqTypReq_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a9549a6e9683629a8f3c48f768da557">
                      <SHORT-NAME>EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_EngFlexplateTqFstTgt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c86f795d92c838a29548d4984507ce83">
                      <SHORT-NAME>EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_EngFlexplateTqSlowTgt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e82ae02d45df37d7ac7739980ee1035b">
                      <SHORT-NAME>EngPhsAng_deg_EngPhsAng_deg_EngPhsAng_deg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="def25e8913d533d4b30d68c5d4da22f5">
                      <SHORT-NAME>EngSlowTqReq_Nm_EngSlowTqReq_Nm_EngSlowTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1365f85fe27c3c5aba6c754862498553">
                      <SHORT-NAME>EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_EngSpdSafe4EngStrt_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2fe2a5ea46333aa08538fbd0a02df1c7">
                      <SHORT-NAME>EngStallCnt_cnt_EngStallCnt_cnt_EngStallCnt_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bc047d44e8dc3efdafac9db9233d2b7c">
                      <SHORT-NAME>EngStall_cnt_EngStall_cnt_EngStall_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7767f11b38b53148903384b38bcf7fef">
                      <SHORT-NAME>EngStopReqCfmd_flg_EngStopReqCfmd_flg_EngStopReqCfmd_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="115bc3b8cf313e9e836572f17bce0030">
                      <SHORT-NAME>EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_EngStrtDampSlipFailCnt_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a92a700f159835ab955ad0532f814261">
                      <SHORT-NAME>EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_EngStrtFailCnt_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fd0323174c14380681e9992dd8d8a009">
                      <SHORT-NAME>EngStrtFail_cnt_EngStrtFail_cnt_EngStrtFail_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b467ef6836c734878a6adeb2ef4e5b4b">
                      <SHORT-NAME>EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_EngStrtNoCapFailCnt_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6633a0a2eb4135ca969f0c56b6f3578e">
                      <SHORT-NAME>EngStrtReq_flg_EngStrtReq_flg_EngStrtReq_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="50d7758b02ef37e6bf7eff42b6949c43">
                      <SHORT-NAME>EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_EngStrtStuckFailCnt_cnt_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="961b94269c8f39549bc245d2833457ce">
                      <SHORT-NAME>FCWSysFltSts_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6acf06fa14b930339892fe88351028b5">
                      <SHORT-NAME>FCWrnngSts_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c1b43d481c403f628bc465a0be8a7cbd">
                      <SHORT-NAME>FMOccupntSts_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="adf394c600703f5e899f92d6e24b3c70">
                      <SHORT-NAME>FasnDrvrSbltIndCmdEvtTyp_SDM_20ms_Group01_SDM_20ms_Group01_SDM_20ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="538640974384326492c98c123c69e545">
                      <SHORT-NAME>FasnDrvrSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2a7be68734ea3301b582cb3fb1b1f4a5">
                      <SHORT-NAME>FasnFrtPsngSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9ccb2a68488130a5befb5761bba5f97a">
                      <SHORT-NAME>FasnFrtRowMidSbltAtcV_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ef276d74d77e34ca8878b3f8b4b3d5f8">
                      <SHORT-NAME>FasnFrtRowMidSbltAtc_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3020243d451e3a538a716a56e0e3c858">
                      <SHORT-NAME>FasnFrtRowMidSbltIndCmd_SDM_20ms_Group02_SDM_20ms_Group02_SDM_20ms_Group02_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a42b1a420df0327d9c74e9ca59487103">
                      <SHORT-NAME>FasnSbltAudRmndr_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="04706504569836b39ed3af2c7d0ae73d">
                      <SHORT-NAME>FasnSecRowLSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="277d60ea1fb33f859889563ad1de0ea7">
                      <SHORT-NAME>FasnSecRowLSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2cf6a9440f2031cb8f5eec9d13b222f7">
                      <SHORT-NAME>FasnSecRowLSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8648e7ffec0436b4b40c874f6edeaf5b">
                      <SHORT-NAME>FasnSecRowMidSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e106ef47589c31db870ba4a21e2c43f6">
                      <SHORT-NAME>FasnSecRowMidSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d5a2ce4bac331ee9c80ab068604e0c2">
                      <SHORT-NAME>FasnSecRowMidSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="74c8bdb483d43952b0247f5b827342bc">
                      <SHORT-NAME>FasnSecRowRSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8d7efaff44735789d107a3bd95a34bd">
                      <SHORT-NAME>FasnSecRowRSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8355847bdac43ccfae52773ae1ce3390">
                      <SHORT-NAME>FasnSecRowRSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e24a1edcfbff3801a43a6462b667b7fe">
                      <SHORT-NAME>FasnThrdRowLSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7a63d72488b430be8ee1ee0415fb412e">
                      <SHORT-NAME>FasnThrdRowLSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ba113867fe73936bcb163d2d2d37a57">
                      <SHORT-NAME>FasnThrdRowLSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cf972f545bd035b8838bdba4d997e2e3">
                      <SHORT-NAME>FasnThrdRowMidSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="81f1c6520bd23d0c93159e36d43032ce">
                      <SHORT-NAME>FasnThrdRowMidSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="650fe83c187338bbae22adcbc89a233d">
                      <SHORT-NAME>FasnThrdRowMidSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b563db363d9f3da3b9bb0af19b652f1e">
                      <SHORT-NAME>FasnThrdRowRSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b7a25e2685b03770b963c88ca572f895">
                      <SHORT-NAME>FasnThrdRowRSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="970b027cca8335099b4aa12a3173405f">
                      <SHORT-NAME>FasnThrdRowRSbltIndCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="0eadb3f69e53380693c433d7cbde1422">
                      <SHORT-NAME>FrtPsngAirbagDsblIndF_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4138d3d10d4e3afbb8431d0624f20fd6">
                      <SHORT-NAME>FrtPsngAirbagEnbIndF_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="387920184d6935eb8739e3f31762b361">
                      <SHORT-NAME>FrtPsngAirbagIndReq_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2844319ed1a73b5d90d693ae375028a5">
                      <SHORT-NAME>FrtPsngAirbagSwSts_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2fdc5f5ed66e3422a5d414c52610e4a8">
                      <SHORT-NAME>FrtPsngSbltAtcV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="235f320fea7e3f1587934befa7764f31">
                      <SHORT-NAME>FrtPsngSbltAtc_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="604b3eb4ff6633288811569cbc240efb">
                      <SHORT-NAME>FuCutReq_enum_FuCutReq_enum_FuCutReq_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="695753cc5fb8326385e437601834750f">
                      <SHORT-NAME>FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_FulCutDMFPrdtn_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7e73c50b3b743190b977d46327ac81b6">
                      <SHORT-NAME>FulCutEngStall_flg_FulCutEngStall_flg_FulCutEngStall_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="53d8242613af36a3a340fbe8fb51f1ad">
                      <SHORT-NAME>FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_FulCutLosCommWthEMS_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a42500e7e2a43ee0b0165c05b5c8c873">
                      <SHORT-NAME>HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_HCUSAMTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="d4825a8a352334b48b957c05a1b7957e">
                      <SHORT-NAME>IBS_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-PDU-PORT UUID="9d874f5b4d72383f8855bd9f9983ad73">
                      <SHORT-NAME>ICBAD_100ms_PDU27_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="bb85da68f6ca39b0a9d3763bb0628d04">
                      <SHORT-NAME>ICBAD_BKPCANFD_100ms_FrP27_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="814f6112f37037ce864e5c344f3d79ac">
                      <SHORT-NAME>IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_NKI_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c49db560dce33e898cf661595d71cc31">
                      <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_NM_BSMtoRMS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d09938e26a23d80b8cd86aaa0efb7b2">
                      <SHORT-NAME>IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_NM_NOSSta_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c95f16d07c603e26bfe874b685573220">
                      <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_NM_NOStoRMS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d9b383da58b03e01a88701c69ff4bc4c">
                      <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_NM_PBSMtoRMS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c990c68374b13110b9eea77b7b176901">
                      <SHORT-NAME>IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_NM_RMSSta_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7212f33739bb348dbaf9978a1cebd1b1">
                      <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_NM_RMStoNOS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="aca25f3a82d63e22bf59bae9212d2baf">
                      <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_NM_RSStoNOS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3c9f226c35c437fba58650bc08020e9b">
                      <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_NM_RSStoRMS_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="47b2b1662a3f31b0a76d43efaa5b4a44">
                      <SHORT-NAME>IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_NOI_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e919b483103e3d5c90e6a8507ac356dc">
                      <SHORT-NAME>IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_NWI_SFCANFD_IPD_SFCANFD_out</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <FRAME-PORT UUID="16a3e60f76ad32a2bc93ffa9378c651c">
                      <SHORT-NAME>IPD_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="ea0ea1a55e7c366aba0ff01d385e92f6">
                      <SHORT-NAME>ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_ISGMaxTqLmt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="16bdd68dfc4134b2839338499ef08a55">
                      <SHORT-NAME>ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_ISGMinTqLmt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="962320fa79ac3e679159a7fd0ba062fa">
                      <SHORT-NAME>ISGTqTgt_Nm_ISGTqTgt_Nm_ISGTqTgt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d2f4c432c286392992c78a56b05c292d">
                      <SHORT-NAME>LDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c64617a328b33904892a670b20c88e93">
                      <SHORT-NAME>LDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3e7ca4707db33e7f874fb0abc4053d2a">
                      <SHORT-NAME>LHZCU_400ms_Group18_CRC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="caf0c8f0c62030139ddb174b2725aa3e">
                      <SHORT-NAME>LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1ad003af99023d66b13f9ae481485c96">
                      <SHORT-NAME>LHZCU_400ms_Group18_RC_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="941e46fc716d3fa4a3cf2c3a6f11a347">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved1_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="62518b7114173c85a149614b18acaa36">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved2_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7aa2e0b881233a96a182d76cde029967">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved3_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="62c89f1609843effa8d683ea2ec5df87">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved4_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="296f95ab970a3f57a6f9b2c370def3d5">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved5_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a9696803ba53c22953eed2012b9440a">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved6_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="54b0dbeb7fe6374fa3b4f0d955eb8596">
                      <SHORT-NAME>LHZCU_400ms_Group18_Reserved7_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="7eea387f097339fc8739c02dbfdee3eb">
                      <SHORT-NAME>LHZCU_400ms_PDU18_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="42a66f0bb5383021be85b2538a1df92d">
                      <SHORT-NAME>LHZCU_LHBKBCANFDF_400ms_FrP18_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="249befe9982638e6b29c633351f630f6">
                      <SHORT-NAME>MONSAMTqReq_Nm_MONSAMTqReq_Nm_MONSAMTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f10f673ed5c2361d8060f844439c4b5c">
                      <SHORT-NAME>MONTMTqReq_Nm_MONTMTqReq_Nm_MONTMTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="207c2cf8eb233d4797cd6913c31f247c">
                      <SHORT-NAME>NmPDU_SFCANFD_IBS_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="cf1e3bffedaf3cc2bb6ff36b74fab38a">
                      <SHORT-NAME>NmPDU_SFCANFD_IPD_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>OUT</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="65ca865f9b063be58850181325d0ad31">
                      <SHORT-NAME>NmPDU_SFCANFD_PEU_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="e8725b47967b3979a8742b97f1147219">
                      <SHORT-NAME>NmPDU_SFCANFD_PICM_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5d525a80567c3521be190bd9ed271adf">
                      <SHORT-NAME>NmPDU_SFCANFD_RZCU_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="6ea3b1400df73bc5969e18da4dde31bb">
                      <SHORT-NAME>NmPDU_SFCANFD_SDM_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="5df3142468ca348b9b40957b744c668d">
                      <SHORT-NAME>NmPDU_SFCANFD_TDM_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="77dcab1f3aad338c8cfa279203b887e3">
                      <SHORT-NAME>PEU_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="61536b1ee5e437799056ca2c7de10e4a">
                      <SHORT-NAME>PICM_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="7786160e013f37cbb61cb826ed557744">
                      <SHORT-NAME>PedtrnProtnSysDplStsV_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="582ebeac0d343f9fadb77122bcfe0833">
                      <SHORT-NAME>PedtrnProtnSysDplSts_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f9f40607027b35d8909025bb1ff9e757">
                      <SHORT-NAME>PedtrnProtnSysIndrCmd_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="df2ec88b09f636df8df2288ba81d40da">
                      <SHORT-NAME>PwrDMd_enum_PwrDMd_enum_PwrDMd_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b6a653141f0b39e58d7c54f29522e6f9">
                      <SHORT-NAME>PwrReq_flg_PwrReq_flg_PwrReq_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="05221f1f0506399ba319419a63aa636f">
                      <SHORT-NAME>RDircnIO_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f749494da99a361191c1505363196a7d">
                      <SHORT-NAME>RDircnIndLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="c2c3152da9ce3727bcec0f61b1b4b3cc">
                      <SHORT-NAME>RZCU_100ms_PDU49_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="c814ed494f7a37a3acd3491df3af5a37">
                      <SHORT-NAME>RZCU_10ms_PDU41_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="2ea7f192c053331c967e85b085f95541">
                      <SHORT-NAME>RZCU_ERCANFD_100ms_FrP49_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="4b654296ac213f0ca0ae71f762b20638">
                      <SHORT-NAME>RZCU_ERCANFD_10ms_FrP41_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="2c9c42e5ed523a7e94c36a79c394ea2a">
                      <SHORT-NAME>RZCU_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="a6f0c07edf7d3058a74d9cea6bf88b9e">
                      <SHORT-NAME>RevsLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="36221f8824733c73bdeba40cc4d11137">
                      <SHORT-NAME>RevsLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="79cd542b281a3c69ba5a0bb4272443f1">
                      <SHORT-NAME>Rolloff2Min_flg_Rolloff2Min_flg_Rolloff2Min_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f58a5718f536371a84174ebea88eae1e">
                      <SHORT-NAME>RolloffHld_flg_RolloffHld_flg_RolloffHld_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="293e11cc35ae3666ae184ab339f37b36">
                      <SHORT-NAME>RrFogLghtF_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1aa82f22176e3d6cbe68ee3f332b1c6c">
                      <SHORT-NAME>RrFogLghtOn_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="7b35904a3208377ba2a3ac18b11b98dc">
                      <SHORT-NAME>SDM_100ms_PDU03_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-SIGNAL-PORT UUID="106d0ab2ae6f34f78849a48e6628338b">
                      <SHORT-NAME>SDM_20ms_Group01_CRC_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bf78f729aae73bc58d7de905d3494d0c">
                      <SHORT-NAME>SDM_20ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6a6e779cd7dc3d77a5a46f817e45a244">
                      <SHORT-NAME>SDM_20ms_Group01_RC_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a85b66d5007d3d728618a18bb6f0ca80">
                      <SHORT-NAME>SDM_20ms_Group01_Reserved1_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a54ad81f18963a818b1e3d976b3aaf8b">
                      <SHORT-NAME>SDM_20ms_Group01_Reserved2_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="87f4345765cf371f8fd653d613554e49">
                      <SHORT-NAME>SDM_20ms_Group01_Reserved3_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a025ee6684f93a6cb9cc72499ecbe3c0">
                      <SHORT-NAME>SDM_20ms_Group01_Reserved4_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="8b785cdb20283ce4bf6cfde7d620f447">
                      <SHORT-NAME>SDM_20ms_Group02_CRC_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="028331268dee3dca94022506fc161f9e">
                      <SHORT-NAME>SDM_20ms_Group02_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="66fade376c253346a5bbcb65b32581b7">
                      <SHORT-NAME>SDM_20ms_Group02_RC_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="98ac4a90926734e7a421ddf17e03d389">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved16_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="1a69d5d3ef1634dbb836d74050d3ecff">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved31_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="cdc34bb266563ffea86c08ab0b1174b0">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved37_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="09892d6323e93ce4b3ae36d95390a877">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved47_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7fa12a5fc98634ebbcee21b1d61a823f">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved51_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3bbe73a7b53c3025b2240b764f7fb168">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved57_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="88cbc8f045a53184a6eeb4bd9f43f83f">
                      <SHORT-NAME>SDM_20ms_Group02_Reserved63_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="cf075c490aae352ba9c4396884cd7b93">
                      <SHORT-NAME>SDM_20ms_PDU01_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <I-PDU-PORT UUID="421696d524c331e59bcd23e613a7e20e">
                      <SHORT-NAME>SDM_20ms_PDU02_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="49e267dd706c3a89aa6aa18fb1f3b1ff">
                      <SHORT-NAME>SDM_CHCANFD_100ms_FrP03_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="e313b42bfa8b3eb5986b889bdb94fa8f">
                      <SHORT-NAME>SDM_CHCANFD_20ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="414095d3dd7330d8b3166ec832a45018">
                      <SHORT-NAME>SDM_CHCANFD_20ms_FrP02_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="d8570f5a81603cf88c0f01fd584c50f1">
                      <SHORT-NAME>SDM_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="9c4a65bdd4bc3b1e868a692caeac18df">
                      <SHORT-NAME>SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_SOCLowPwrDwn_flg_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="bbd143f3c912350885e34880e156c081">
                      <SHORT-NAME>SOCLvl_enum_SOCLvl_enum_SOCLvl_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
