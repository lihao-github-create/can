                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X137</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X138</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X139</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X140</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X141</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X142</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X143</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X144</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X145</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X146</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU257/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329d3500">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAQukChgSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e0d00">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPDCPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329cc900">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMMCUPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c0c00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329a5b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngReq_ZXD</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ba000">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRAirMdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329b8500">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLAirMdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329b6a00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACIonizerReqSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329b4f00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACFreshSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c5d00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMClmOnOffSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c2700">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACSyncSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329bd600">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRTemIncSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329bbb00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRTemDecSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c4200">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMAirClnrBlwrLvlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329bf100">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRTemReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329afe00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngVcCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329a9200">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAParkInOffsetTypeReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c7800">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMIFPACOnOffSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329d5000">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAReportSetSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ce400">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329dbc00">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>68</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ae300">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329b1900">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSAdoWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ac800">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutoLaneChngSetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329aad00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPASWReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>77</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329a7700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAPAOneKeyParkSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e4200">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarRoVslAssQuit</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329cae00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCRSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329c9300">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtCarGoNotfrSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>85</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329b3400">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESSswReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329d8600">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>89</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329d6b00">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOPCitySwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>91</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329d1a00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOALaneSetSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>93</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329cff00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INOAETCSetSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329f5000">
                  <SHORT-NAME>X146</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IWlcmLghtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>96</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329eae00">
                  <SHORT-NAME>X140</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>98</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329dd700">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IParkngDirSw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>101</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329da100">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadBwdAssConfrmSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ec900">
                  <SHORT-NAME>X141</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDistToDsttnNavForSus</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329f1a00">
                  <SHORT-NAME>X144</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrwlLghtReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>112</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329eff00">
                  <SHORT-NAME>X143</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFollowMeHomeReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>113</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e5d00">
                  <SHORT-NAME>X137</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMChrgSttnMchngSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>115</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329ee400">
                  <SHORT-NAME>X142</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCMPowerFailSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>117</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e9300">
                  <SHORT-NAME>X139</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ID2DPriETClanSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329f3500">
                  <SHORT-NAME>X145</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFWrnngMdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>126</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e7800">
                  <SHORT-NAME>X138</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngEPAMdsw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329a49xOa505a3f19f25843c4b329e2800">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEBSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>135</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b309230XOa505a3f19f25843c4b30922f00">
              <SHORT-NAME>ICBVC_100ms_PDU27</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU27/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30930000">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAVMDspReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>1</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b3092af00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHDCReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30925e00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmmsnTestMdFICMV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b3092ca00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSOCReqFICM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30927900">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMPwrDMdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30929400">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMPwrDMdReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30924200">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEmmsnTestMdFICM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30935100">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMPwrDMdReqV_AIHEV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30931b00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISusDmpngCtrlCustSetngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b3092e500">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrgtSOCReqFICMV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b309230xOa505a3f19f25843c4b30933600">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMPwrDMdReq_AIHEV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32a005XOa505a3f19f25843c4b32a00400">
              <SHORT-NAME>ICBVC_100ms_PDU31</SHORT-NAME>
              <LENGTH>20</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU31/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a03300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdCtlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a01700">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngSpdsw</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a06900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadsltReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>100</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a04e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INrwroadFwdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a09f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>121</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32a005xOa505a3f19f25843c4b32a08400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IMemPkngSlntPtrlEnbSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>131</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30761aXOa505a3f19f25843c4b30761900">
              <SHORT-NAME>ICBVC_100ms_PDU35</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU35/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30766300">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSnstvtLvlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30764800">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IELKSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>9</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30769900">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWAdoWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30767e00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFCWSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b3077c200">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrfcLghtFuctionSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30772000">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDOWSelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30770500">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBSDSelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30762c00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAEBSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b3076b400">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKAHptWrnngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30778c00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRCWSelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30775600">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INarwSpcAstSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b3076ea00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWSnstvtLvlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b3077a700">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRDASwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30777100">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRCTSysSelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b30773b00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILCASelReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30761axOa505a3f19f25843c4b3076cf00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILDWLKASwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b2f87b6XOa505a3f19f25843c4b2f87b500">
              <SHORT-NAME>ICBVC_100ms_PDU47</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU47/FOTAStatus</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU47/FOTAStatusValid</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU47/FOTATarget</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU47/FOTATargetValid</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f87b6xOa505a3f19f25843c4b2f87e400">
                  <SHORT-NAME>FOTAStatusValid</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTAStatusValid</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f87b6xOa505a3f19f25843c4b2f87c800">
                  <SHORT-NAME>FOTAStatus</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTAStatus</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f87b6xOa505a3f19f25843c4b2f87ff00">
                  <SHORT-NAME>FOTATarget</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTATarget</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b2f87b6xOa505a3f19f25843c4b2f881a00">
                  <SHORT-NAME>FOTATargetValid</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFOTATargetValid</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3089dfXOa505a3f19f25843c4b3089de00">
              <SHORT-NAME>ICBVC_100ms_PDU48</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU48/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU48/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU48/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU48/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU48/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3089dfxOa505a3f19f25843c4b308a0e00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDCDCVolStpt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3089dfxOa505a3f19f25843c4b308a2900">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISLIFUpdtIndReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3089dfxOa505a3f19f25843c4b3089f300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBatVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3089dfxOa505a3f19f25843c4b308a5f00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISprSportSubItemReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3089dfxOa505a3f19f25843c4b308a4400">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISprSportSubItemReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30a202XOa505a3f19f25843c4b30a20100">
              <SHORT-NAME>ICBVC_100ms_PDU80</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/FrtPsngAirbagSwStsReqV_Sfty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/FrtPsngAirbagSwStsReq_Sfty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/ICBVC_100ms_Group80_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/ICBVC_100ms_Group80_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/VehDrvngMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/VehLdShedLvl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/VehOdo</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/VehOdoV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_100ms_PDU80/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a24400">
                  <SHORT-NAME>ICBVC_100ms_Group80_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a25f00">
                  <SHORT-NAME>ICBVC_100ms_Group80_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a21400">
                  <SHORT-NAME>VehDrvngMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehDrvngMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a29500">
                  <SHORT-NAME>VehOdo</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehOdo</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a30100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a27a00">
                  <SHORT-NAME>VehLdShedLvl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehLdShedLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a2b000">
                  <SHORT-NAME>VehOdoV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehOdoV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a31c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a2e600">
                  <SHORT-NAME>FrtPsngAirbagSwStsReqV_Sfty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReqV_Sfty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a2cb00">
                  <SHORT-NAME>FrtPsngAirbagSwStsReq_Sfty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPsngAirbagSwStsReq_Sfty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a33700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_100ms_Group80_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a202xOa505a3f19f25843c4b30a23000">
                  <SHORT-NAME>ICBVC_100ms_Group80</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_100ms_Group80</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30bfdcXOa505a3f19f25843c4b30bfdb00">
              <SHORT-NAME>ICBVC_200ms_PDU50</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshDay</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshHr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshMins</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshMth</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshSec</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/VehTiPblshYear</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU50/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.2</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c07600">
                  <SHORT-NAME>VehTiPblshYear</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshYear</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c04000">
                  <SHORT-NAME>VehTiPblshMth</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshMth</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30bfee00">
                  <SHORT-NAME>VehTiPblshDay</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshDay</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c00a00">
                  <SHORT-NAME>VehTiPblshHr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshHr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>28</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c02500">
                  <SHORT-NAME>VehTiPblshMins</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshMins</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c05b00">
                  <SHORT-NAME>VehTiPblshSec</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehTiPblshSec</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30bfdcxOa505a3f19f25843c4b30c09100">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITimeDspFmt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30a367XOa505a3f19f25843c4b30a36600">
              <SHORT-NAME>ICBVC_200ms_PDU79</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_200ms_PDU79/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.2</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a3df00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a3fa00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a43000">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrlrMdSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a37900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a3a900">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPTNotReadyReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a41500">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdAirbagWrnng</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a44b00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a46600">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_200ms_Group79_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a3c400">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOdoPriyPrcs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a367xOa505a3f19f25843c4b30a39500">
                  <SHORT-NAME>ICBVC_200ms_Group79</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_200ms_Group79</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3093c4XOa505a3f19f25843c4b3093c300">
              <SHORT-NAME>ICBVC_20ms_PDU00</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/TDMAvlbly</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU00/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30967a00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INFCAMAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>2</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30973700">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISASAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>4</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30947900">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDMAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>5</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30945e00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHZCUAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>6</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30944300">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHZCUAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3095f300">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITC_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>8</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30960e00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_SFAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>9</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30950000">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEPSAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>10</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30969500">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITC_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3093d700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xN200000119f873e8a4f3de7900">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILVBM_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3096cb00">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>16</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3096b000">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_ERAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>17</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3093f200">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPICU_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30965f00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHRDAAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30955100">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30978700">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHMPWCAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30949400">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>22</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3094ca00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30953600">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESS_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>24</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3094af00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCU_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30942800">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAMAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>26</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3095a200">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEAC_Avlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30970100">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_SFAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3096e600">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPEU_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30975200">
                  <SHORT-NAME>TDMAvlbly</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITDMAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30964400">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_SFAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30971c00">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_ExtdAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3097a100">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISAC_PTAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3094e500">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCEOPAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>38</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3095d800">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRZCU_BKBCANFDAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b3095bd00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_BKPCANFDAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30962900">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIPD_CHCANFDAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30951b00">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIBS_CHAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30956c00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30958700">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHRDAAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30940d00">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCMAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3093c4xOa505a3f19f25843c4b30976c00">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30a496XOa505a3f19f25843c4b30a49500">
              <SHORT-NAME>ICBVC_20ms_PDU03</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/AMRPrtensonReq</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/BPMMstrAvlbly</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/ICBVC_20ms_Group03_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/ICBVC_20ms_Group03_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/PwrMdMstrAccryA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/PwrMdMstrRunCrkA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysOpnlMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysPwrMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysPwrMdV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysVol</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysVolMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysVolMdV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/SysVolV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/UsgMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/UsgMdV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/VehMd</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/VehMdV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_20ms_PDU03/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.02</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a4f300">
                  <SHORT-NAME>ICBVC_20ms_Group03_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a50e00">
                  <SHORT-NAME>ICBVC_20ms_Group03_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a4a800">
                  <SHORT-NAME>AMRPrtensonReq</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAMRPrtensonReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a6a300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a5e600">
                  <SHORT-NAME>SysVolMdV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolMdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a68800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a6be00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>27</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a65200">
                  <SHORT-NAME>VehMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a60100">
                  <SHORT-NAME>SysVolV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a59500">
                  <SHORT-NAME>SysPwrMdV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a66d00">
                  <SHORT-NAME>VehMdV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehMdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a63700">
                  <SHORT-NAME>UsgMdV</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IUsgMdV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a61c00">
                  <SHORT-NAME>UsgMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IUsgMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a5b000">
                  <SHORT-NAME>SysVol</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVol</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a54400">
                  <SHORT-NAME>PwrMdMstrRunCrkA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdMstrRunCrkA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a57a00">
                  <SHORT-NAME>SysPwrMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysPwrMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a52900">
                  <SHORT-NAME>PwrMdMstrAccryA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdMstrAccryA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a55f00">
                  <SHORT-NAME>SysOpnlMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysOpnlMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a6d900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_20ms_Group03_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a4d800">
                  <SHORT-NAME>BPMMstrAvlbly</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBPMMstrAvlbly</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a5cb00">
                  <SHORT-NAME>SysVolMd</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISysVolMd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a496xOa505a3f19f25843c4b30a4c400">
                  <SHORT-NAME>ICBVC_20ms_Group03</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_20ms_Group03</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30a911XOa505a3f19f25843c4b30a91000">
              <SHORT-NAME>ICBVC_250ms_PDU52</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_250ms_PDU52/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_250ms_PDU52/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_250ms_PDU52/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_250ms_PDU52/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.25</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a911xOa505a3f19f25843c4b30a93f00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrValV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a911xOa505a3f19f25843c4b30a95a00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrValMsk</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a911xOa505a3f19f25843c4b30a97500">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemVDA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30a911xOa505a3f19f25843c4b30a92300">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOtsdAirTemCrVal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b3088c4XOa505a3f19f25843c4b3088c300">
              <SHORT-NAME>ICBVC_500ms_PDU67</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_500ms_PDU67/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.5</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b3089af00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILghtWlcmMdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b3088d600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAvgFuelCsumpPrcs</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30890d00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIgnOffTime</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b3088f200">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAvgFuelCsumpPrcsV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30895e00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAvgFuelCsumpV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30892800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIgnOffTimeV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30894300">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAvgFuelCsump</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30899400">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRCPDMdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b3088c4xOa505a3f19f25843c4b30897900">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRCPDDlyTimeSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33bc50XOa505a3f19f25843c4b33bc4f00">
              <SHORT-NAME>ICBVC_50ms_PDU11</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsCanclSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsDistDecSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsDistIncSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsOnSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsRsmSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsSpdDecSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsSpdIncSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/CCSwStsSwDataIntgty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/HMISafFltsts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/ICBVC_50ms_Group11_CRC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/ICBVC_50ms_Group11_RC</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/PfTrTapUpDwnEnbSwSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/PfTrTapUpDwnSecySwSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/PfTrTapUpDwnSwSta</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SWSCnfmSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SWSSelDwnSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SWSSelLSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SWSSelRSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SWSSelUpSwA</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/StrgWhlTipcSwDataIntgty</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/SwStaE2EErr</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/TrPfShftPtrnSw1A</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/TrPfShftPtrnSw2A</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/TrPfShftPtrnSw3A</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/TrPfShftPtrnSw4A</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU11/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bc7700">
                  <SHORT-NAME>ICBVC_50ms_Group11_CRC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bc9200">
                  <SHORT-NAME>ICBVC_50ms_Group11_RC</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33beae00">
                  <SHORT-NAME>TrPfShftPtrnSw3A</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw3A</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be9300">
                  <SHORT-NAME>TrPfShftPtrnSw2A</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw2A</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be4200">
                  <SHORT-NAME>PfTrTapUpDwnSwSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnSwSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf1a00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf3400">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be5d00">
                  <SHORT-NAME>StrgWhlTipcSwDataIntgty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IStrgWhlTipcSwDataIntgty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>32</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf4e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bce300">
                  <SHORT-NAME>CCSwStsDistIncSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistIncSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bcc800">
                  <SHORT-NAME>CCSwStsDistDecSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsDistDecSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bd4f00">
                  <SHORT-NAME>CCSwStsSpdIncSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdIncSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bd3400">
                  <SHORT-NAME>CCSwStsSpdDecSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSpdDecSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bd6a00">
                  <SHORT-NAME>CCSwStsSwDataIntgty</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSwDataIntgty</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bcfe00">
                  <SHORT-NAME>CCSwStsOnSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsOnSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bcad00">
                  <SHORT-NAME>CCSwStsCanclSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCanclSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be0c00">
                  <SHORT-NAME>PfTrTapUpDwnEnbSwSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnEnbSwSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be2700">
                  <SHORT-NAME>PfTrTapUpDwnSecySwSta</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPfTrTapUpDwnSecySwSta</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf6800">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33be7800">
                  <SHORT-NAME>TrPfShftPtrnSw1A</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw1A</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf8200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bdf100">
                  <SHORT-NAME>SWSSelUpSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelUpSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bdd600">
                  <SHORT-NAME>SWSSelRSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelRSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bdbb00">
                  <SHORT-NAME>SWSSelLSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelLSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bda000">
                  <SHORT-NAME>SWSSelDwnSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelDwnSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>53</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bd8500">
                  <SHORT-NAME>SWSCnfmSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSCnfmSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>54</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bd1900">
                  <SHORT-NAME>CCSwStsRsmSwA</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsRsmSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bf9c00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group11_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>56</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bee400">
                  <SHORT-NAME>HMISafFltsts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHMISafFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33beff00">
                  <SHORT-NAME>SwStaE2EErr</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISwStaE2EErr</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bec900">
                  <SHORT-NAME>TrPfShftPtrnSw4A</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITrPfShftPtrnSw4A</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33bc50xOa505a3f19f25843c4b33bc6400">
                  <SHORT-NAME>ICBVC_50ms_Group11</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group11</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30b7f2XOa505a3f19f25843c4b30b7f100">
              <SHORT-NAME>ICBVC_50ms_PDU13</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU13/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b8d500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b8f000">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b92600">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b94100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b95c00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b8ba00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITgtParkingChosed</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b89f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtMdFICM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b83300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAutocParkngSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b90b00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMATESysSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b97700">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b99200">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b88400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPwrMdCtrlResp</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b9ad00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b9c800">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b9e300">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30ba1900">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>84</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b86900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRDircnLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>85</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b9fe00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>86</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b84e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLDircnLghtFltsts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30ba4f00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved12</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b80400">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrSsdManuCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>92</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30ba3400">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30ba6a00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved13</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30ba8500">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved14</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30baa000">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved15</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30babb00">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group13_Reserved16</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30b7f2xOa505a3f19f25843c4b30b82000">
                  <SHORT-NAME>ICBVC_50ms_Group13</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group13</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b33b9c1XOa505a3f19f25843c4b33b9c000">
              <SHORT-NAME>ICBVC_50ms_PDU158</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU158/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33b9e800">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba0300">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba6f00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdDecAndIncVcCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba5400">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisDecAndIncVcCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33badb00">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>19</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba3900">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsSetSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba1e00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSwStsCCASwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>21</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33ba8a00">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bac000">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCSpdVcCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33baf600">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb1100">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved3</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33baa500">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICCDisAdjtVcCmd</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb2c00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved4</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb4700">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved5</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb6200">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved6</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb7d00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved7</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bb9800">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved8</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bbb300">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved9</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bbce00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved10</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bbe900">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved11</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bc0400">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved12</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33bc1f00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group158_Reserved13</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b33b9c1xOa505a3f19f25843c4b33b9d400">
                  <SHORT-NAME>ICBVC_50ms_Group158</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group158</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32c011XOa505a3f19f25843c4b32c01000">
              <SHORT-NAME>ICBVC_50ms_PDU256</SHORT-NAME>
              <LENGTH>16</LENGTH>
              <CONTAINED-I-PDU-PROPS>
                <COLLECTION-SEMANTICS>LAST-IS-BEST</COLLECTION-SEMANTICS>
                <HEADER-ID-SHORT-HEADER>900054</HEADER-ID-SHORT-HEADER>
                <TIMEOUT>0.035</TIMEOUT>
                <TRIGGER>NEVER</TRIGGER>
              </CONTAINED-I-PDU-PROPS>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU256/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c03500">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_CRC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c05100">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_RC</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>11</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c17a00">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB3SwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c1b000">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelRSwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>13</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c19500">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSSelLSwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c15f00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB2SwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c08700">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c0bd00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlope</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c12900">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSLFnChngSwA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c10e00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSCnfmSwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c0a200">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadCrvtDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c0d800">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoadSlopeDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c14400">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPB1SwStuckL</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c06c00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDMSSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c0f300">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetectionDist</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c21500">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved85</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>85</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c23000">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved95</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>95</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c28100">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved96</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>96</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c1fa00">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IVehboardSetting</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>98</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c26600">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved100</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>100</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c1df00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRoughRoaddetection</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>101</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c24b00">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved103</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c29c00">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved111</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>111</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c2b700">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved119</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>119</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c2d200">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICBVC_50ms_Group256_Reserved127</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32c011xOa505a3f19f25843c4b32c1cb00">
                  <SHORT-NAME>ICBVC_50ms_Group256</SHORT-NAME>
                  <I-SIGNAL-GROUP-REF DEST="I-SIGNAL-GROUP">/Communication/Signals/IICBVC_50ms_Group256</I-SIGNAL-GROUP-REF>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b335a6eXOa505a3f19f25843c4b335a6d00">
              <SHORT-NAME>ICBVC_50ms_PDU55</SHORT-NAME>
              <LENGTH>12</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/DrvrDstrctnSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/DrvrFtgLvl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/ICMDrvrDstcnSts</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/ICMDrvrFtgLvl</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/ICMDrvrPrst</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_50ms_PDU55/ICMEyeOnRoad</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.05</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335a9c00">
                  <SHORT-NAME>DrvrFtgLvl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrFtgLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335b0800">
                  <SHORT-NAME>ICMEyeOnRoad</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMEyeOnRoad</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335a8000">
                  <SHORT-NAME>DrvrDstrctnSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDstrctnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335ab700">
                  <SHORT-NAME>ICMDrvrDstcnSts</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrDstcnSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335aed00">
                  <SHORT-NAME>ICMDrvrPrst</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrPrst</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335a6exOa505a3f19f25843c4b335ad200">
                  <SHORT-NAME>ICMDrvrFtgLvl</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IICMDrvrFtgLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b32b909XOa505a3f19f25843c4b32b90800">
              <SHORT-NAME>ICBVC_SecOCComKeyReq_PDU01</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_SecOCComKeyReq_PDU01/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_SecOCComKeyReq_PDU01/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b909xOa505a3f19f25843c4b32b93700">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITripCntResetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>6</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b32b909xOa505a3f19f25843c4b32b91b00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IComKeyEnbReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b335b38XOa505a3f19f25843c4b335b3700">
              <SHORT-NAME>ICBVC_SecOC_SyncMsg</SHORT-NAME>
              <LENGTH>5</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <MINIMUM-DELAY>0.005</MINIMUM-DELAY>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_SecOC_SyncMsg/ResetCnt</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_SecOC_SyncMsg/TripCnt</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335b38xOa505a3f19f25843c4b335b6a00">
                  <SHORT-NAME>TripCnt</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITripCnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b335b38xOa505a3f19f25843c4b335b4e00">
                  <SHORT-NAME>ResetCnt</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IResetCnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b329f81XOa505a3f19f25843c4b329f8000">
              <SHORT-NAME>ICBVC_Sporadic_PDU138</SHORT-NAME>
              <LENGTH>24</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICBVC_Sporadic_PDU138/AIParkngReqICB</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <EVENT-CONTROLLED-TIMING>
                        <NUMBER-OF-REPETITIONS>0</NUMBER-OF-REPETITIONS>
                      </EVENT-CONTROLLED-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b329f81xOa505a3f19f25843c4b329f9300">
                  <SHORT-NAME>AIParkngReqICB</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIParkngReqICB</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>TRIGGERED</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b307f1dXOa505a3f19f25843c4b307f1c00">
              <SHORT-NAME>ICB_100ms_PDU146</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU146/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxN200000119f4464397e2eb4600">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEMCLPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>12</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30823f00">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>14</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307f8100">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IESCLPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>20</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3080e000">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBPEPSPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>25</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30811600">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IARHUDPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>29</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307fed00">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHAmbtLampPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>30</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30805900">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IOHCPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307f4b00">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICnsoDspPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307fb700">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLVntngMotPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>34</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307f9c00">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLSLMMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3080aa00">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IUSBHubPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>36</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307f6600">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDrvrDspPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30808f00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISWSPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>38</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307f2f00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IBrkSwPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b307fd200">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IHODMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30807400">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRLSSPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30818200">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IETCMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30800800">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ILHSWPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30802300">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INFCAMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30803e00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INFCSMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3080fb00">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISACPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30814c00">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICnsoUSBPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3081ee00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrPDCPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30819d00">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPDCPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>52</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3080c500">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFVCMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30820900">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITPMSPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30822400">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAIBOTPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3081d300">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIterMirPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b3081b800">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIMSPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>61</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30813100">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICPDPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>62</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b307f1dxOa505a3f19f25843c4b30816700">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IDABMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b30798dXOa505a3f19f25843c4b30798c00">
              <SHORT-NAME>ICB_100ms_PDU147</SHORT-NAME>
              <LENGTH>8</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU147/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a9300">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHSwPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a7800">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRHAmbtLampPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>41</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b3079bb00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICnsoUSB1PwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b30799f00">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IAirVentMotPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>44</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307ac900">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ICFPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a4200">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRVntngMotPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>48</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a0c00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFRSLMMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a2700">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtPwrSktPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>50</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307ae400">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFrtSDAPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b3079f100">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFLiDARPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>58</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307a5d00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIAMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b307aae00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISDMPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>60</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b30798dxOa505a3f19f25843c4b3079d600">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFDRPwrSts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
              </I-SIGNAL-TO-PDU-MAPPINGS>
              <UNUSED-BIT-PATTERN>255</UNUSED-BIT-PATTERN>
            </I-SIGNAL-I-PDU>
            <I-SIGNAL-I-PDU UUID="Oa505a3f19f25843c4b306c3dXOa505a3f19f25843c4b306c3c00">
              <SHORT-NAME>ICB_100ms_PDU159</SHORT-NAME>
              <LENGTH>64</LENGTH>
              <I-PDU-TIMING-SPECIFICATIONS>
                <I-PDU-TIMING>
                  <TRANSMISSION-MODE-DECLARATION>
                    <TRANSMISSION-MODE-CONDITIONS>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/TrgtSOCReqAI</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/TrgtSOCReqAIV</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X1</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X11</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X110</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X111</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X112</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X113</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X114</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X115</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X116</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X117</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X118</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X119</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X12</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X120</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X121</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X122</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X123</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X124</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X125</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X126</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X127</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X128</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X129</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X13</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X130</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X131</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X132</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X133</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X134</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X135</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X136</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X137</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X138</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X139</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X14</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X140</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X141</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X142</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X143</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X144</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X145</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X146</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X147</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X148</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X149</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X15</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X150</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X151</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X152</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X153</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X154</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X155</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X156</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X157</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X158</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X159</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X16</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X160</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X161</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X162</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X163</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X164</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X165</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X166</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X167</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X168</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X169</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X17</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X170</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X171</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X172</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X18</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                      <TRANSMISSION-MODE-CONDITION>
                        <DATA-FILTER>
                          <DATA-FILTER-TYPE>ALWAYS</DATA-FILTER-TYPE>
                        </DATA-FILTER>
                        <I-SIGNAL-IN-I-PDU-REF DEST="I-SIGNAL-TO-I-PDU-MAPPING">/Communication/PDUs/ICB_100ms_PDU159/X19</I-SIGNAL-IN-I-PDU-REF>
                      </TRANSMISSION-MODE-CONDITION>
                    </TRANSMISSION-MODE-CONDITIONS>
                    <TRANSMISSION-MODE-TRUE-TIMING>
                      <CYCLIC-TIMING>
                        <TIME-PERIOD>
                          <VALUE>0.1</VALUE>
                        </TIME-PERIOD>
                      </CYCLIC-TIMING>
                    </TRANSMISSION-MODE-TRUE-TIMING>
                  </TRANSMISSION-MODE-DECLARATION>
                </I-PDU-TIMING>
              </I-PDU-TIMING-SPECIFICATIONS>
              <I-SIGNAL-TO-PDU-MAPPINGS>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30719700">
                  <SHORT-NAME>X150</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrDspdVehSpd_mph</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>7</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30726f00">
                  <SHORT-NAME>X156</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrSsdPosCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>15</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306cbd00">
                  <SHORT-NAME>X14</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCTJAMdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>18</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e6d00">
                  <SHORT-NAME>X120</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLTemReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>23</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306fcc00">
                  <SHORT-NAME>X133</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>31</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306ca200">
                  <SHORT-NAME>X13</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCStsSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>33</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306c8700">
                  <SHORT-NAME>X12</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCSpdLimtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>35</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306c6c00">
                  <SHORT-NAME>X11</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCCurveSpdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>37</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306c5000">
                  <SHORT-NAME>X1</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACCConfmSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>39</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d5f00">
                  <SHORT-NAME>X110</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustEcoSetngReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>40</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d4400">
                  <SHORT-NAME>X19</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustEcoSetngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>42</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d2900">
                  <SHORT-NAME>X18</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustAutoMdBlwrReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>43</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d0e00">
                  <SHORT-NAME>X17</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustAutoMdBlwrReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>45</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306cf300">
                  <SHORT-NAME>X16</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustAftRunOnOffReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>46</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306cd800">
                  <SHORT-NAME>X15</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IACUserCustAftRunOnOffR</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>47</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306dcb00">
                  <SHORT-NAME>X114</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACFrtBlwrSpdDecSwR</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>49</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d9500">
                  <SHORT-NAME>X112</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACAutoSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>51</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306d7a00">
                  <SHORT-NAME>X111</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IADAudioSWReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>55</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e3700">
                  <SHORT-NAME>X118</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLTemDecSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>57</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306de600">
                  <SHORT-NAME>X115</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACFrtBlwrSpdIncSwR</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>59</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306db000">
                  <SHORT-NAME>X113</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACFrtBlwrLvlReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>63</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306ea300">
                  <SHORT-NAME>X122</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACOnOffSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>65</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e5200">
                  <SHORT-NAME>X119</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLTemIncSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>67</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e1c00">
                  <SHORT-NAME>X117</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLAirMdReqV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>68</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e0100">
                  <SHORT-NAME>X116</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLAirMdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>71</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f0f00">
                  <SHORT-NAME>X126</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMComprOnOffSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>73</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306ef400">
                  <SHORT-NAME>X125</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACSemiAutoSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>75</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306ed900">
                  <SHORT-NAME>X124</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRcctnSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>77</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306ebe00">
                  <SHORT-NAME>X123</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACRcctnMdReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>79</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f4500">
                  <SHORT-NAME>X128</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMHtdRrWndSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>81</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f2a00">
                  <SHORT-NAME>X127</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMDfstOnSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>83</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306e8800">
                  <SHORT-NAME>X121</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IFICMACLTemV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>87</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306fe700">
                  <SHORT-NAME>X134</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITLRMdSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>90</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30700200">
                  <SHORT-NAME>X135</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITSRSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>97</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f7b00">
                  <SHORT-NAME>X130</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/INonDirectDMSSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>99</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f9600">
                  <SHORT-NAME>X131</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetNumReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>103</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306f6000">
                  <SHORT-NAME>X129</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IILCSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>108</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30703800">
                  <SHORT-NAME>X137</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IASSInhBtnA</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>109</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30701d00">
                  <SHORT-NAME>X136</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IClstrElecCsumpUnit</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>114</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b306fb100">
                  <SHORT-NAME>X132</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ISpdLmtOfstSetPercReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>127</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3070a400">
                  <SHORT-NAME>X141</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBSBatSOFVol1</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>143</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3070da00">
                  <SHORT-NAME>X143</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBSBatSOFVol2</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>151</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3070f500">
                  <SHORT-NAME>X144</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBSBatSOFVol2Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>153</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30711000">
                  <SHORT-NAME>X145</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGenrExctnCrnt</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>159</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30705300">
                  <SHORT-NAME>X138</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IASSStsFICM</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>160</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3070bf00">
                  <SHORT-NAME>X142</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBSBatSOFVol1Sts</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>162</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30712b00">
                  <SHORT-NAME>X146</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IGenrExctnDutyCyc</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>167</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3071e800">
                  <SHORT-NAME>X153</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCPreSpdLimtSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>169</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30717c00">
                  <SHORT-NAME>X149</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPMDCIlgclIdficn</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>170</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30708900">
                  <SHORT-NAME>X140</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IEBSBatIncnstncyFlag</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>171</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30706e00">
                  <SHORT-NAME>X139</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IASSStsFICMV</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>172</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30716100">
                  <SHORT-NAME>X148</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IPMDCIlgclCal</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>173</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30714600">
                  <SHORT-NAME>X147</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIdleBstLvl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>175</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3071b200">
                  <SHORT-NAME>X151</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IExtnlTstrDet</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>176</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30720300">
                  <SHORT-NAME>X154</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/ITiltSnsrSetngReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>178</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30728a00">
                  <SHORT-NAME>X157</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IRrSsdAppCtrl</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>180</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b3071cd00">
                  <SHORT-NAME>X152</SHORT-NAME>
                  <I-SIGNAL-REF DEST="I-SIGNAL">/Communication/Signals/IIACCOvTSuppresSwReq</I-SIGNAL-REF>
                  <PACKING-BYTE-ORDER>MOST-SIGNIFICANT-BYTE-FIRST</PACKING-BYTE-ORDER>
                  <START-POSITION>183</START-POSITION>
                  <TRANSFER-PROPERTY>PENDING</TRANSFER-PROPERTY>
                </I-SIGNAL-TO-I-PDU-MAPPING>
                <I-SIGNAL-TO-I-PDU-MAPPING UUID="Oa505a3f19f25843c4b306c3dxOa505a3f19f25843c4b30723900">
                  <SHORT-NAME>TrgtSOCReqAI</SHORT-NAME>
