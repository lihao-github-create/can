                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_100ms_Group10/RZCU_100ms_Group10</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_100ms_Group10</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/EleccLckCtrlResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EleccLckCtrlResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/FlbStrgFnSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FlbStrgFnSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/FlbStrgFnStsResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FlbStrgFnStsResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/IMU_Signal_status</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMU_Signal_status</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OfbdChrgrNgtvSktTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OfbdChrgrNgtvSktTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OfbdChrgrNgtvSktTemV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OfbdChrgrNgtvSktTemV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OnBdChrgrSktElecLckSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSktElecLckSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OnBdChrgrSktElecLckStaV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSktElecLckStaV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OnBdChrgrSktPstvSnsrTem</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSktPstvSnsrTem</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OnBdChrgrSktPstvSnsrTemV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnBdChrgrSktPstvSnsrTemV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/OnbdChrgrSktEleccLckEnable</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/OnbdChrgrSktEleccLckEnable</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/RZCU_100ms_Group10_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_100ms_Group10_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_100ms_Group10/VCUCtrlS2Req</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUCtrlS2Req</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group01/RZCU_10ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/AutoChrgngMngmnt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoChrgngMngmnt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTAccelActuPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTAccelActuPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTAccelActuPosV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTAccelActuPosV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTAccelEfctvPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTAccelEfctvPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTBrkPdlDscrtInptSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTBrkPdlDscrtInptSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTBrkPdlDscrtInptStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTBrkPdlDscrtInptStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTCrkAbotd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTCrkAbotd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTHVDCDCMdReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTHVDCDCMdReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTHVEmgcPwrOffReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTHVEmgcPwrOffReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTMainRelayDrvReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTMainRelayDrvReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/EPTStCmdOn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTStCmdOn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/ElecMotEmgcShutDwn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ElecMotEmgcShutDwn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RVSEPTRdy</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RVSEPTRdy</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RZCU_10ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RZCU_10ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RZCU_10ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RZCU_10ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group01/RZCU_10ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group02/RZCU_10ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTSecyAxleInptShaftSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTSecyAxleInptShaftSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTSecyAxleInptShaftSpdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTSecyAxleInptShaftSpdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTTrInptShaftSpd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrInptShaftSpd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTTrInptShaftSpdV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrInptShaftSpdV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTTrInptShaftSpdV_R</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrInptShaftSpdV_R</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/EPTTrInptShaftSpd_R</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrInptShaftSpd_R</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/RZCU_10ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/RZCU_10ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group02/RZCU_10ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group22</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group22/RZCU_10ms_Group22</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group22</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotMaxAvlblToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotMaxAvlblToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotMaxAvlblToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotMaxAvlblToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotMinAvlblToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotMinAvlblToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotMinAvlblToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotMinAvlblToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotToq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotToq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/EPTTrOtptShaftTotToqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTTrOtptShaftTotToqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/RZCU_10ms_Group22_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/RZCU_10ms_Group22_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/RZCU_10ms_Group22_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/RZCU_10ms_Group22_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group22_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/VMCTarReWhlTqMaxLmt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarReWhlTqMaxLmt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/VMCTarReWhlTqMaxLmtV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarReWhlTqMaxLmtV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/VMCTarWhlTqMaxLmt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarWhlTqMaxLmt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group22/VMCTarWhlTqMaxLmtV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VMCTarWhlTqMaxLmtV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group23</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group23/RZCU_10ms_Group23</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group23</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/AIPilotSysSaBrInh</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotSysSaBrInh</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/AIPilotSysSaBrSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotSysSaBrSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/AccelOvrd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelOvrd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/AutodDrvngToqReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutodDrvngToqReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/PtACCToqReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PtACCToqReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/PtAPAToqReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PtAPAToqReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved10</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved10</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved11</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved11</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved12</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved12</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved13</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved13</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved14</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved14</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved7</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved7</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved8</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved8</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group23/RZCU_10ms_Group23_Reserved9</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group23_Reserved9</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group24</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group24/RZCU_10ms_Group24</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group24</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/EPTAPARevrDrgReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTAPARevrDrgReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/PtAPASts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PtAPASts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/RZCU_10ms_Group24_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group24_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/VCUAPAFltRsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUAPAFltRsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group24/VCUAPAUnderCtrlA</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCUAPAUnderCtrlA</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_10ms_Group90</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_10ms_Group90/RZCU_10ms_Group90</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_10ms_Group90</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved135</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved135</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved143</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved143</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved151</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved151</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved159</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved159</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved83</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved83</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved87</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved87</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/RZCU_10ms_Group90_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_10ms_Group90_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_10ms_Group90/VCU_ISAOvSpdOvRd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VCU_ISAOvSpdOvRd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_20ms_Group06</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_20ms_Group06/RZCU_20ms_Group06</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_20ms_Group06</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/EPTRdy</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTRdy</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/EPTRdyV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTRdyV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/RZCU_20ms_Group06_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_20ms_Group06_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrEngdSta</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdSta</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrEngdStaV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdStaV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrEstdGear</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGear</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrEstdGearV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGearV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrShftLvrPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_20ms_Group06/TrShftLvrPosV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPosV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_50ms_Group37</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_50ms_Group37/RZCU_50ms_Group37</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_50ms_Group37</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/BrkLghtFltSts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtFltSts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/BrkLghtSts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtSts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/ChrgrFlapLtchCtrl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChrgrFlapLtchCtrl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/LdspcOpenSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LdspcOpenSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/LdspcOpenStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LdspcOpenStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/PwrLftgtClsSwtActv</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PwrLftgtClsSwtActv</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RLDircnLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RLDircnLghtFltsts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtFltsts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RLDircnLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RLDircnLghtSts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RLDircnLghtSts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RRDircnLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RRDircnLghtFltsts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtFltsts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RRDircnLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RRDircnLghtSts_HW</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RRDircnLghtSts_HW</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved23</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved23</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved34</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved34</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved36</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved36</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved38</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved38</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RZCU_50ms_Group37_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_50ms_Group37_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RearFogLghtFltsts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RearFogLghtFltsts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RearFogLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RearFogLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RevsLghtFltSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtFltSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_50ms_Group37/RevsLghtSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/RZCU_ZONE_10ms_Group64</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/RZCU_ZONE_10ms_Group64</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationXsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationXsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationXsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationXsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationYsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationYsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationYsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationYsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationZsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationZsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AccelerationZsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AccelerationZsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateXsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateXsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateXsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateXsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateYsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateYsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateYsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateYsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateZsecinfo</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateZsecinfo</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/AngularRateZsecinfoV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AngularRateZsecinfoV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/IMUTmp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMUTmp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/IMUseq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMUseq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved5</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved5</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/RZCU_ZONE_10ms_Group64_Reserved6</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCU_ZONE_10ms_Group64_Reserved6</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/TireBlowoutPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TireBlowoutPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/RZCU_ZONE_10ms_Group64/TireBlowoutStabCtrlSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TireBlowoutStabCtrlSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group01/SDM_20ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/AirbagDplForeCall</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplForeCall</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/AirbagDplInvsneForeCall</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplInvsneForeCall</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/AirbagSysFltForeCall</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFltForeCall</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/DrvrSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/DrvrSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnDrvrSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnDrvrSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnDrvrSbltIndCmdEvtTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnDrvrSbltIndCmdEvtTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnFrtPsngSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnFrtPsngSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSbltAudRmndr</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSbltAudRmndr</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowLSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowLSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowLSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowLSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowLSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowLSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowMidSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowMidSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowMidSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowMidSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowMidSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowMidSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowRSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowRSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowRSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowRSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnSecRowRSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnSecRowRSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowLSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowLSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowLSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowLSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowLSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowLSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowMidSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowMidSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowMidSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowMidSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowMidSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowMidSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowRSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowRSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowRSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowRSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FasnThrdRowRSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnThrdRowRSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FrtPsngSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/FrtPsngSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group01/SDM_20ms_Group01_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group02/SDM_20ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/AirbagDpl</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDpl</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/AirbagDplInvsn</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagDplInvsn</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/AirbagSysFlt</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFlt</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/AirbagSysFltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AirbagSysFltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FMOccupntSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FMOccupntSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FasnFrtRowMidSbltAtc</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnFrtRowMidSbltAtc</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FasnFrtRowMidSbltAtcV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnFrtRowMidSbltAtcV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FasnFrtRowMidSbltIndCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FasnFrtRowMidSbltIndCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FrtPsngAirbagDsblIndF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagDsblIndF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FrtPsngAirbagEnbIndF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagEnbIndF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FrtPsngAirbagIndReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagIndReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/FrtPsngAirbagSwSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngAirbagSwSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/PedtrnProtnSysDplSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PedtrnProtnSysDplSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/PedtrnProtnSysDplStsV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PedtrnProtnSysDplStsV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/PedtrnProtnSysIndrCmd</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/PedtrnProtnSysIndrCmd</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved16</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved16</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved31</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved31</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved37</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved37</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved51</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved51</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved57</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved57</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/SDM_20ms_Group02_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group02/VehCrshTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehCrshTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/SDM_20ms_Group03</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/SDM_20ms_Group03/SDM_20ms_Group03</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/SDM_20ms_Group03</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/SDM_20ms_Group03_Reserved4</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VSELatAccV_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELatAccV_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VSELatAcc_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELatAcc_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VSELongtAccV_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELongtAccV_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VSELongtAcc_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VSELongtAcc_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VehDynYawRateV_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDynYawRateV_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/SDM_20ms_Group03/VehDynYawRate_SDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehDynYawRate_SDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_020ms_PDU18</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_020ms_PDU18/TCM_020ms_PDU18</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_020ms_PDU18</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/CluActTorq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CluActTorq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/SCUAPAUnderCtrlA_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUAPAUnderCtrlA_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/SCUDrvrIntrvnA_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvrIntrvnA_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TCM_020ms_PDU18_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TCM_020ms_PDU18_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TCM_020ms_PDU18_Reserve01</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve01</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TCM_020ms_PDU18_Reserve02</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve02</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TCM_020ms_PDU18_Reserve03</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_020ms_PDU18_Reserve03</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_020ms_PDU18/TrAPACanclReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrAPACanclReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_025ms_Group02</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_025ms_Group02/TCM_025ms_Group02</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_025ms_Group02</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/AutocTrCmddGear_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutocTrCmddGear_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/DrvrShftCtrlReqDndIO</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrShftCtrlReqDndIO</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/DrvrShftCtrlTrgtGear_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrShftCtrlTrgtGear_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TCM_025ms_Group02_Reserved1</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved1</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TCM_025ms_Group02_Reserved2</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved2</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TCM_025ms_Group02_Reserved3</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_Group02_Reserved3</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TCM_025ms_PDU02_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU02_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TCM_025ms_PDU02_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU02_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrCrpMdA_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrCrpMdA_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrEPBAppReq</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEPBAppReq</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrEngdStaV_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdStaV_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrEngdSta_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEngdSta_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrEstdGearV_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGearV_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrEstdGear_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrEstdGear_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrIntnlSwPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrIntnlSwPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrIntnlSwPosV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrIntnlSwPosV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrPrkPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrkPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrPrkSysF</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrkSysF</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrShftLvrPosV_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPosV_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrShftLvrPos_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftLvrPos_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrShftPtrnASts_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrShftPtrnASts_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrTapUpTapDwnMdSts_TCM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrTapUpTapDwnMdSts_TCM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_Group02/TrTrgtShftLvrPos</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrTrgtShftLvrPos</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_025ms_PDU20</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_025ms_PDU20/TCM_025ms_PDU20</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_025ms_PDU20</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_Reserve01</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve01</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_Reserve02</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve02</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_Reserve03</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve03</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TCM_025ms_PDU20_Reserve04</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU20_Reserve04</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_025ms_PDU20/TrACCToqReqResp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrACCToqReqResp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TCM_PTCAN_FrP05</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TCM_PTCAN_FrP05/TCM_PTCAN_FrP05</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TCM_PTCAN_FrP05</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TCM_025ms_PDU05_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TCM_025ms_PDU05_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TCM_025ms_PDU05_Reserve01</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TCM_025ms_PDU05_Reserve01</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrGear</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrGear</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrGearV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrGearV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrImmdCrkshftToqReqVal</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrImmdCrkshftToqReqVal</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrImmdCrkshftToqRespTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrImmdCrkshftToqRespTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrPrdtdCrkshftToqIntrvnTyp</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrdtdCrkshftToqIntrvnTyp</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TCM_PTCAN_FrP05/TrPrdtdCrkshftToqReqV</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrPrdtdCrkshftToqReqV</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/TDM_200ms_Group01</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/TDM_200ms_Group01/TDM_200ms_Group01</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SIGNAL-GROUP-REF DEST="SYSTEM-SIGNAL-GROUP">/Communication/SystemSignalGroups/TDM_200ms_Group01</SIGNAL-GROUP-REF>
                  <TYPE-MAPPING>
                    <SENDER-REC-RECORD-TYPE-MAPPING>
                      <RECORD-ELEMENT-MAPPINGS>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/BrkLghtF_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtF_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/BrkLghtOn_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BrkLghtOn_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/LDircnIO_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDircnIO_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/LDircnIndLghtF_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/LDircnIndLghtF_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RDircnIO_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDircnIO_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RDircnIndLghtF_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RDircnIndLghtF_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RevsLghtF_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtF_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RevsLghtOn_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtOn_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RrFogLghtF_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLghtF_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/RrFogLghtOn_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLghtOn_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_CRC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_CRC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_RC</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_RC</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved103</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved103</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved111</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved111</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved119</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved119</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved127</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved127</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved15</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved15</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved27</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved27</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved39</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved39</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved47</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved47</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved55</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved55</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved63</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved63</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved71</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved71</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved79</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved79</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved87</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved87</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TDM_200ms_Group01_Reserved95</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TDM_200ms_Group01_Reserved95</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/TrlrCnctSts</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/TrlrCnctSts</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                        <SENDER-REC-RECORD-ELEMENT-MAPPING>
                          <IMPLEMENTATION-RECORD-ELEMENT-REF DEST="IMPLEMENTATION-DATA-TYPE-ELEMENT">/DataTypes/ImplementationDataTypes/TDM_200ms_Group01/VehSideLghtSts_TDM</IMPLEMENTATION-RECORD-ELEMENT-REF>
                          <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/VehSideLghtSts_TDM</SYSTEM-SIGNAL-REF>
                        </SENDER-REC-RECORD-ELEMENT-MAPPING>
                      </RECORD-ELEMENT-MAPPINGS>
                    </SENDER-REC-RECORD-TYPE-MAPPING>
                  </TYPE-MAPPING>
                </SENDER-RECEIVER-TO-SIGNAL-GROUP-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCConfmSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCConfmSw/ACCConfmSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCConfmSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCConfmSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCConfmSwReq/ACCConfmSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCConfmSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCCurveSpdSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCCurveSpdSw/ACCCurveSpdSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCCurveSpdSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCCurveSpdSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCCurveSpdSwReq/ACCCurveSpdSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCCurveSpdSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1ExistPrblty/ACCDetObj1ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Id</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1Id/ACCDetObj1Id</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Id</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LatRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1LatRltvDist/ACCDetObj1LatRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LatRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LongtRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvDist/ACCDetObj1LongtRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LongtRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1LongtRltvSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1LongtRltvSpd/ACCDetObj1LongtRltvSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1LongtRltvSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Risk</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1Risk/ACCDetObj1Risk</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Risk</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1SyncCtr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1SyncCtr/ACCDetObj1SyncCtr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1SyncCtr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj1Typ</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj1Typ/ACCDetObj1Typ</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj1Typ</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2ExistPrblty/ACCDetObj2ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Id</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2Id/ACCDetObj2Id</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Id</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LatRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2LatRltvDist/ACCDetObj2LatRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LatRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LongtRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvDist/ACCDetObj2LongtRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LongtRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2LongtRltvSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2LongtRltvSpd/ACCDetObj2LongtRltvSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2LongtRltvSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Risk</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2Risk/ACCDetObj2Risk</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Risk</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2SyncCtr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2SyncCtr/ACCDetObj2SyncCtr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2SyncCtr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj2Typ</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj2Typ/ACCDetObj2Typ</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj2Typ</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3ExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3ExistPrblty/ACCDetObj3ExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3ExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Id</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3Id/ACCDetObj3Id</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Id</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LatRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3LatRltvDist/ACCDetObj3LatRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LatRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LongtRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvDist/ACCDetObj3LongtRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LongtRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3LongtRltvSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3LongtRltvSpd/ACCDetObj3LongtRltvSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3LongtRltvSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Risk</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3Risk/ACCDetObj3Risk</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Risk</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3SyncCtr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3SyncCtr/ACCDetObj3SyncCtr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3SyncCtr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObj3Typ</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObj3Typ/ACCDetObj3Typ</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObj3Typ</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjExistPrblty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjExistPrblty/ACCDetObjExistPrblty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjExistPrblty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjHdngAng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjHdngAng/ACCDetObjHdngAng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjHdngAng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjId</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjId/ACCDetObjId</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjId</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLatRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjLatRltvDist/ACCDetObjLatRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLatRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLongtRltvDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvDist/ACCDetObjLongtRltvDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLongtRltvDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjLongtRltvSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjLongtRltvSpd/ACCDetObjLongtRltvSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjLongtRltvSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjRisk</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjRisk/ACCDetObjRisk</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjRisk</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjSyncCtr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjSyncCtr/ACCDetObjSyncCtr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjSyncCtr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDetObjTyp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDetObjTyp/ACCDetObjTyp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDetObjTyp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCDrvrTkovReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCDrvrTkovReq/ACCDrvrTkovReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCDrvrTkovReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCObjDet</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCObjDet/ACCObjDet</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCObjDet</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCSpdLimtSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCSpdLimtSw/ACCSpdLimtSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSpdLimtSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCSpdLimtSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCSpdLimtSwReq/ACCSpdLimtSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCSpdLimtSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCStsForEdr/ACCStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCStsSw/ACCStsSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCStsSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCStsSwReq/ACCStsSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCStsSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACCTJAMdSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACCTJAMdSwReq/ACCTJAMdSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACCTJAMdSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrAStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrAStsForEdr/ACSFCatgrAStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrAStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrB1StsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrB1StsForEdr/ACSFCatgrB1StsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrB1StsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrB2StsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrB2StsForEdr/ACSFCatgrB2StsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrB2StsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrCStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrCStsForEdr/ACSFCatgrCStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrCStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrDStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrDStsForEdr/ACSFCatgrDStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrDStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ACSFCatgrEStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ACSFCatgrEStsForEdr/ACSFCatgrEStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ACSFCatgrEStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADAudioSWReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADAudioSWReq/ADAudioSWReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADAudioSWReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADAudioSWSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADAudioSWSts/ADAudioSWSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADAudioSWSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISAMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADS_ISAMsgReq/ADS_ISAMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISAMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISASysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADS_ISASysFltSts/ADS_ISASysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISASysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ADS_ISASysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ADS_ISASysSts/ADS_ISASysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ADS_ISASysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AEBDspCmd/AEBDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AEBMsgReq/AEBMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AEBStsForEdr/AEBStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AEBSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AEBSwReq/AEBSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AEBSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngDsp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngDsp/AIParkngDsp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngDsp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngEPAMdsts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngEPAMdsts/AIParkngEPAMdsts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngEPAMdsts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngEPAMdsw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngEPAMdsw/AIParkngEPAMdsw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngEPAMdsw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReq/AIParkngReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReqICB</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReqICB/AIParkngReqICB</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReqICB</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngReq_ZXD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngReq_ZXD/AIParkngReq_ZXD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngReq_ZXD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngRespICB</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngRespICB/AIParkngRespICB</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngRespICB</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSSPLotSw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSSPLotSw/AIParkngSSPLotSw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSSPLotSw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSSPLotSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSSPLotSwSts/AIParkngSSPLotSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSSPLotSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSpcID</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSpcID/AIParkngSpcID</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSpcID</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSpdsw</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSpdsw/AIParkngSpdsw</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSpdsw</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIParkngSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIParkngSts/AIParkngSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIParkngSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AIPilotIntervQuit</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AIPilotIntervQuit/AIPilotIntervQuit</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AIPilotIntervQuit</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAOneKeyParkSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APAOneKeyParkSwReq/APAOneKeyParkSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAOneKeyParkSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAParkInOffsetType</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APAParkInOffsetType/APAParkInOffsetType</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAParkInOffsetType</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APAParkInOffsetTypeReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APAParkInOffsetTypeReq/APAParkInOffsetTypeReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APAParkInOffsetTypeReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APARemShifGear</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APARemShifGear/APARemShifGear</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APARemShifGear</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APASW/APASW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASWReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APASWReq/APASWReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASWReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/APASpdMdSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/APASpdMdSwSts/APASpdMdSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/APASpdMdSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVMDspReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVMDspReq/AVMDspReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVMDspReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVMSt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVMSt/AVMSt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVMSt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AVPMapRutMgIDtReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AVPMapRutMgIDtReq/AVPMapRutMgIDtReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AVPMapRutMgIDtReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngSetReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngSetReq/AutoLaneChngSetReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSetReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngSwReq/AutoLaneChngSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoLaneChngVcCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoLaneChngVcCmd/AutoLaneChngVcCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoLaneChngVcCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoMainBeamLghtOn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoMainBeamLghtOn/AutoMainBeamLghtOn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoMainBeamLghtOn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/AutoMainBeamLghtReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/AutoMainBeamLghtReq/AutoMainBeamLghtReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/AutoMainBeamLghtReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/BSDSelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/BSDSelReq/BSDSelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BSDSelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/BaseLineLen</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/BaseLineLen/BaseLineLen</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/BaseLineLen</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CANprotocolinternalversion</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CANprotocolinternalversion/CANprotocolinternalversion</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CANprotocolinternalversion</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCSpdVcCmdCnfm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCSpdVcCmdCnfm/CCSpdVcCmdCnfm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdVcCmdCnfm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CCSpdlVcCmdSwReqDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CCSpdlVcCmdSwReqDspCmd/CCSpdlVcCmdSwReqDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CCSpdlVcCmdSwReqDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/CSFStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/CSFStsForEdr/CSFStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/CSFStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ChrgPwrReq_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ChrgPwrReq_kW/ChrgPwrReq_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChrgPwrReq_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ChrgReq_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ChrgReq_flg/ChrgReq_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ChrgReq_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ClstrDspdVehSpd_mph</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ClstrDspdVehSpd_mph/ClstrDspdVehSpd_mph</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ClstrDspdVehSpd_mph</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ComKeyEnbReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ComKeyEnbReq/ComKeyEnbReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ComKeyEnbReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DPriETClanSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DPriETClanSwReq/D2DPriETClanSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/D2DPriETClanSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DPriETClanSwReqResps</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DPriETClanSwReqResps/D2DPriETClanSwReqResps</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/D2DPriETClanSwReqResps</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DSwReq/D2DSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/D2DSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSwReqResps</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DSwReqResps/D2DSwReqResps</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/D2DSwReqResps</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/D2DSysSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/D2DSysSts/D2DSysSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/D2DSysSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_0</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_0/DFC_Current_DisplyBuffer_0</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DFC_Current_DisplyBuffer_0</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_1/DFC_Current_DisplyBuffer_1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DFC_Current_DisplyBuffer_1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DFC_Current_DisplyBuffer_2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DFC_Current_DisplyBuffer_2/DFC_Current_DisplyBuffer_2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DFC_Current_DisplyBuffer_2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DMSCameraFps_IMM</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DMSCameraFps_IMM/DMSCameraFps_IMM</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DMSCameraFps_IMM</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DOWSelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DOWSelReq/DOWSelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DOWSelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DTCInfomationIPD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DTCInfomationIPD/DTCInfomationIPD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DTCInfomationIPD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DetourMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DetourMsgReq/DetourMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DetourMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DfstOnDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DfstOnDspCmd/DfstOnDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DfstOnDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DiffAgeInfo</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DiffAgeInfo/DiffAgeInfo</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DiffAgeInfo</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DiffDataLinkBroken</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DiffDataLinkBroken/DiffDataLinkBroken</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DiffDataLinkBroken</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DircnIndLghtMdSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DircnIndLghtMdSts/DircnIndLghtMdSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnIndLghtMdSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DircnIndLghtSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DircnIndLghtSwSts/DircnIndLghtSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DircnIndLghtSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DistSinceTrgtCamr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DistSinceTrgtCamr/DistSinceTrgtCamr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistSinceTrgtCamr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DistToTrfcJamNav</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DistToTrfcJamNav/DistToTrfcJamNav</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DistToTrfcJamNav</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DownVelocityRTK</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DownVelocityRTK/DownVelocityRTK</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DownVelocityRTK</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlFilt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlFilt_Nm/DrvTqReqWhlFilt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvTqReqWhlFilt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlRawCap_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlRawCap_Nm/DrvTqReqWhlRawCap_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvTqReqWhlRawCap_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvTqReqWhlRaw_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvTqReqWhlRaw_Nm/DrvTqReqWhlRaw_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvTqReqWhlRaw_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvrDstrctnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvrDstrctnSts/DrvrDstrctnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrDstrctnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DrvrFtgLvl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DrvrFtgLvl/DrvrFtgLvl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DrvrFtgLvl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DsblICE_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DsblICE_flg/DsblICE_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DsblICE_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DsblISG_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DsblISG_flg/DsblISG_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DsblISG_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/DschrgOptMaxPwr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/DschrgOptMaxPwr/DschrgOptMaxPwr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/DschrgOptMaxPwr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUClntTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUClntTem/EDUClntTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EDUClntTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUClntTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUClntTemV/EDUClntTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EDUClntTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUOilTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUOilTem/EDUOilTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EDUOilTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EDUOilTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EDUOilTemV/EDUOilTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EDUOilTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ELKDspCmd/ELKDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ELKSwReq/ELKSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKSysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ELKSysFltSts/ELKSysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKSysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ELKWarning</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ELKWarning/ELKWarning</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ELKWarning</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EORWarningEvtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EORWarningEvtSts/EORWarningEvtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EORWarningEvtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPSAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPSAvlbly/EPSAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPSCTTX</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPSCTTX/EPSCTTX</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPSCTTX</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPTClntPumpSta</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPTClntPumpSta/EPTClntPumpSta</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTClntPumpSta</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EPTElecWtrPumpActuSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EPTElecWtrPumpActuSpd/EPTElecWtrPumpActuSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EPTElecWtrPumpActuSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCBrkRgnPwrLmt_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCBrkRgnPwrLmt_kW/ERCBrkRgnPwrLmt_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCBrkRgnPwrLmt_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCChrgPwrLmtPeak_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtPeak_kW/ERCChrgPwrLmtPeak_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCChrgPwrLmtPeak_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCChrgPwrLmtWhl_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCChrgPwrLmtWhl_kW/ERCChrgPwrLmtWhl_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCChrgPwrLmtWhl_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCDsChrgPwrLmtPeak_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtPeak_kW/ERCDsChrgPwrLmtPeak_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCDsChrgPwrLmtPeak_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCDsChrgPwrLmtWhl_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCDsChrgPwrLmtWhl_kW/ERCDsChrgPwrLmtWhl_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCDsChrgPwrLmtWhl_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCEmgcyPwrDwn_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCEmgcyPwrDwn_flg/ERCEmgcyPwrDwn_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCEmgcyPwrDwn_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCFCOReq_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCFCOReq_flg/ERCFCOReq_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCFCOReq_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCHVAllwd_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCHVAllwd_flg/ERCHVAllwd_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCHVAllwd_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCHVHldReq_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCHVHldReq_flg/ERCHVHldReq_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCHVHldReq_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCMaxChrgPwrLmt_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCMaxChrgPwrLmt_kW/ERCMaxChrgPwrLmt_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCMaxChrgPwrLmt_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ERCMaxDschgPwrLmt_kW</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ERCMaxDschgPwrLmt_kW/ERCMaxDschgPwrLmt_kW</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ERCMaxDschgPwrLmt_kW</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESCLPwrSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESCLPwrSts/ESCLPwrSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESCLPwrSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESFStsForEdr</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESFStsForEdr/ESFStsForEdr</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESFStsForEdr</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSAdoWrnngDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSAdoWrnngDspCmd/ESSAdoWrnngDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSAdoWrnngDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSAdoWrnngReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSAdoWrnngReq/ESSAdoWrnngReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSAdoWrnngReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSDspCmd/ESSDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ESSswReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ESSswReq/ESSswReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ESSswReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EVMd_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EVMd_flg/EVMd_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EVMd_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EastVelocityRTK</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EastVelocityRTK/EastVelocityRTK</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EastVelocityRTK</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ElecPwrDistbnScene</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ElecPwrDistbnScene/ElecPwrDistbnScene</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ElecPwrDistbnScene</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/En12VoltStrMotCmddOn</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/En12VoltStrMotCmddOn/En12VoltStrMotCmddOn</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/En12VoltStrMotCmddOn</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngBrkTqMax_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngBrkTqMax_Nm/EngBrkTqMax_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngBrkTqMax_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFastTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFastTqReq_Nm/EngFastTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngFastTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFastTqTypReq_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFastTqTypReq_enum/EngFastTqTypReq_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngFastTqTypReq_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFlexplateTqFstTgt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFlexplateTqFstTgt_Nm/EngFlexplateTqFstTgt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngFlexplateTqFstTgt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngFlexplateTqSlowTgt_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngFlexplateTqSlowTgt_Nm/EngFlexplateTqSlowTgt_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngFlexplateTqSlowTgt_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngPhsAng_deg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngPhsAng_deg/EngPhsAng_deg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngPhsAng_deg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngSlowTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngSlowTqReq_Nm/EngSlowTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngSlowTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngSpdSafe4EngStrt_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngSpdSafe4EngStrt_flg/EngSpdSafe4EngStrt_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngSpdSafe4EngStrt_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStallCnt_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStallCnt_cnt/EngStallCnt_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStallCnt_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStall_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStall_cnt/EngStall_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStall_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStopReqCfmd_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStopReqCfmd_flg/EngStopReqCfmd_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStopReqCfmd_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtDampSlipFailCnt_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtDampSlipFailCnt_cnt/EngStrtDampSlipFailCnt_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtDampSlipFailCnt_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtFailCnt_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtFailCnt_cnt/EngStrtFailCnt_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtFailCnt_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtFail_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtFail_cnt/EngStrtFail_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtFail_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtNoCapFailCnt_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtNoCapFailCnt_cnt/EngStrtNoCapFailCnt_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtNoCapFailCnt_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtReq_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtReq_flg/EngStrtReq_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtReq_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EngStrtStuckFailCnt_cnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EngStrtStuckFailCnt_cnt/EngStrtStuckFailCnt_cnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EngStrtStuckFailCnt_cnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD1/EvtPotclSigIPD1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD2/EvtPotclSigIPD2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD3</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD3/EvtPotclSigIPD3</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD3</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD4</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD4/EvtPotclSigIPD4</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD4</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD5</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD5/EvtPotclSigIPD5</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD5</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD6</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD6/EvtPotclSigIPD6</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD6</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD7</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD7/EvtPotclSigIPD7</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD7</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/EvtPotclSigIPD8</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/EvtPotclSigIPD8/EvtPotclSigIPD8</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/EvtPotclSigIPD8</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTBSysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTBSysFltSts/FCTBSysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTBSysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTBSysFltSts_ADAS</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTBSysFltSts_ADAS/FCTBSysFltSts_ADAS</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTBSysFltSts_ADAS</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSwSts/FCTSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSwSts_ADAS</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSwSts_ADAS/FCTSwSts_ADAS</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTSwSts_ADAS</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysFltSts/FCTSysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTSysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysFltSts_ADAS</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysFltSts_ADAS/FCTSysFltSts_ADAS</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTSysFltSts_ADAS</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCTSysSelReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCTSysSelReq/FCTSysSelReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCTSysSelReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWDspCmd/FCWDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSnstvtLvl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSnstvtLvl/FCWSnstvtLvl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWSnstvtLvl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSnstvtLvlReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSnstvtLvlReq/FCWSnstvtLvlReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWSnstvtLvlReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSwReq/FCWSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWSysFltSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWSysFltSts/FCWSysFltSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWSysFltSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FCWrnngSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FCWrnngSts/FCWrnngSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FCWrnngSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FDRPwrSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FDRPwrSts/FDRPwrSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FDRPwrSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDircnLghtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDircnLghtSts/FLDircnLghtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDircnLghtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDoorHndlPESwtActv</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDoorHndlPESwtActv/FLDoorHndlPESwtActv</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDoorHndlPESwtActv</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLDoorOpenSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLDoorOpenSts/FLDoorOpenSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLDoorOpenSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLObsRng/FLObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSObsRng/FLSObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSUSSSts/FLSUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLSideObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLSideObsRng/FLSideObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLSideObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTirePrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTirePrs/FLTirePrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLTirePrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTirePrsV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTirePrsV/FLTirePrsV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLTirePrsV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireSts/FLTireSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLTireSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireTem/FLTireTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLTireTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLTireTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLTireTemV/FLTireTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLTireTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLUSSSts/FLUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FLiDARPwrSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FLiDARPwrSts/FLiDARPwrSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FLiDARPwrSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FMLUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FMLUSSSts/FMLUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FMLUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FMRUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FMRUSSSts/FMRUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FMRUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTAStatus</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTAStatus/FOTAStatus</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FOTAStatus</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTAStatusValid</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTAStatusValid/FOTAStatusValid</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FOTAStatusValid</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTATarget</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTATarget/FOTATarget</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FOTATarget</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FOTATargetValid</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FOTATargetValid/FOTATargetValid</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FOTATargetValid</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDircnLghtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDircnLghtSts/FRDircnLghtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDircnLghtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDoorHndlPESwtActv</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDoorHndlPESwtActv/FRDoorHndlPESwtActv</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDoorHndlPESwtActv</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRDoorOpenSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRDoorOpenSts/FRDoorOpenSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRDoorOpenSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRObsRng/FRObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSObsRng/FRSObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSUSSSts/FRSUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRSideObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRSideObsRng/FRSideObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRSideObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTirePrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTirePrs/FRTirePrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRTirePrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTirePrsV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTirePrsV/FRTirePrsV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRTirePrsV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireSts/FRTireSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRTireSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireTem/FRTireTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRTireTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRTireTemV</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRTireTemV/FRTireTemV</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRTireTemV</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FRUSSSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FRUSSSts/FRUSSSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FRUSSSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCamrHeatCtrl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCamrHeatCtrl/FrtCamrHeatCtrl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCamrHeatCtrl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCamrHeatSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCamrHeatSts/FrtCamrHeatSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCamrHeatSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCarGoNotfrDspCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCarGoNotfrDspCmd/FrtCarGoNotfrDspCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCarGoNotfrDspCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtCarGoNotfrSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtCarGoNotfrSwReq/FrtCarGoNotfrSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtCarGoNotfrSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtMidLObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtMidLObsRng/FrtMidLObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtMidLObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtMidRObsRng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtMidRObsRng/FrtMidRObsRng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtMidRObsRng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtObsDist</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtObsDist/FrtObsDist</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtObsDist</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtPDCAudWrnng</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtPDCAudWrnng/FrtPDCAudWrnng</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPDCAudWrnng</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtPsngDoorOpenSts_LHZCU</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtPsngDoorOpenSts_LHZCU/FrtPsngDoorOpenSts_LHZCU</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtPsngDoorOpenSts_LHZCU</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtTireStdPrs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtTireStdPrs/FrtTireStdPrs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtTireStdPrs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSfcTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSfcTem/FrtWindShldSfcTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtWindShldSfcTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSurndHmdty</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSurndHmdty/FrtWindShldSurndHmdty</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtWindShldSurndHmdty</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWindShldSurndTem</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWindShldSurndTem/FrtWindShldSurndTem</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtWindShldSurndTem</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWiperSpd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWiperSpd/FrtWiperSpd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtWiperSpd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FrtWiperSwSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FrtWiperSwSts/FrtWiperSwSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FrtWiperSwSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FuCutReq_enum</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FuCutReq_enum/FuCutReq_enum</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FuCutReq_enum</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutDMFPrdtn_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutDMFPrdtn_flg/FulCutDMFPrdtn_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FulCutDMFPrdtn_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutEngStall_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutEngStall_flg/FulCutEngStall_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FulCutEngStall_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/FulCutLosCommWthEMS_flg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/FulCutLosCommWthEMS_flg/FulCutLosCommWthEMS_flg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/FulCutLosCommWthEMS_flg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/GNSSAntennasBroken</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/GNSSAntennasBroken/GNSSAntennasBroken</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSAntennasBroken</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/GNSSAntennasInfo</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/GNSSAntennasInfo/GNSSAntennasInfo</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/GNSSAntennasInfo</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HCUSAMTqReq_Nm</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HCUSAMTqReq_Nm/HCUSAMTqReq_Nm</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HCUSAMTqReq_Nm</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HORWarningEvtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HORWarningEvtSts/HORWarningEvtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HORWarningEvtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPFnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPFnSts/HPPFnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HPPFnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPInBmtSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPInBmtSts/HPPInBmtSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HPPInBmtSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPMapBuildSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPMapBuildSts/HPPMapBuildSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HPPMapBuildSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HPPOnRoutSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HPPOnRoutSts/HPPOnRoutSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HPPOnRoutSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/HmdtySnsrHdwrFltPrst</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/HmdtySnsrHdwrFltPrst/HmdtySnsrHdwrFltPrst</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/HmdtySnsrHdwrFltPrst</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCOvTSuppresCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCOvTSuppresCmd/IACCOvTSuppresCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IACCOvTSuppresCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCOvTSuppresSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCOvTSuppresSwReq/IACCOvTSuppresSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IACCOvTSuppresSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreMsgReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreMsgReq/IACCPreMsgReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IACCPreMsgReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreSpdLimtCmd</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreSpdLimtCmd/IACCPreSpdLimtCmd</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IACCPreSpdLimtCmd</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IACCPreSpdLimtSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IACCPreSpdLimtSwReq/IACCPreSpdLimtSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IACCPreSpdLimtSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAMAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAMAvlbly/IAMAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAMAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IAMReststs</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IAMReststs/IAMReststs</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IAMReststs</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IBS_CHAvlbly</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IBS_CHAvlbly/IBS_CHAvlbly</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IBS_CHAvlbly</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrDstcnSts</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrDstcnSts/ICMDrvrDstcnSts</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMDrvrDstcnSts</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrFtgLvl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrFtgLvl/ICMDrvrFtgLvl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMDrvrFtgLvl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMDrvrPrst</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMDrvrPrst/ICMDrvrPrst</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMDrvrPrst</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMEyeOnRoad</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMEyeOnRoad/ICMEyeOnRoad</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMEyeOnRoad</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMSwReq_Reserve16</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve16/ICMSwReq_Reserve16</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMSwReq_Reserve16</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ICMSwReq_Reserve17</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ICMSwReq_Reserve17/ICMSwReq_Reserve17</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ICMSwReq_Reserve17</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/ILCSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/ILCSwReq/ILCSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ILCSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IMU_SN</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IMU_SN/IMU_SN</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IMU_SN</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAVCamrHeatReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAVCamrHeatReq/IPDAVCamrHeatReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDAVCamrHeatReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAlgFlag</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAlgFlag/IPDAlgFlag</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDAlgFlag</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDAurixTemp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDAurixTemp/IPDAurixTemp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDAurixTemp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDComKeyEnbResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDComKeyEnbResp/IPDComKeyEnbResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDComKeyEnbResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDDataId</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDDataId/IPDDataId</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDDataId</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDErrorCount</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDErrorCount/IPDErrorCount</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDErrorCount</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDFailedReason</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDFailedReason/IPDFailedReason</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDFailedReason</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDIdentityResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDIdentityResp/IPDIdentityResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDIdentityResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDKeyStatus</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDKeyStatus/IPDKeyStatus</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDKeyStatus</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDMCUTemp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDMCUTemp/IPDMCUTemp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDMCUTemp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPCBTemp1</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPCBTemp1/IPDPCBTemp1</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDPCBTemp1</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPCBTemp2</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPCBTemp2/IPDPCBTemp2</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDPCBTemp2</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPMICTemp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPMICTemp/IPDPMICTemp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDPMICTemp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDPowerFailSwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDPowerFailSwReq/IPDPowerFailSwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDPowerFailSwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDResetCnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDResetCnt/IPDResetCnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDResetCnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDSOCTemp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDSOCTemp/IPDSOCTemp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDSOCTemp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDStsResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDStsResp/IPDStsResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDStsResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDThermalWrnngLvl</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDThermalWrnngLvl/IPDThermalWrnngLvl</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDThermalWrnngLvl</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripCnt</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripCnt/IPDTripCnt</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDTripCnt</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripCntResetResp</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripCntResetResp/IPDTripCntResetResp</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDTripCntResetResp</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDTripNvmTag</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDTripNvmTag/IPDTripNvmTag</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDTripNvmTag</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltFlwReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltFlwReq/IPDWtrClntInltFlwReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDWtrClntInltFlwReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltReqFlg</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltReqFlg/IPDWtrClntInltReqFlg</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDWtrClntInltReqFlg</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPDWtrClntInltTimeReq</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPDWtrClntInltTimeReq/IPDWtrClntInltTimeReq</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPDWtrClntInltTimeReq</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_BKPCANFD/IPD_NKI_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NKI_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_CHCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_CHCANFD/IPD_NKI_CHCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NKI_CHCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_PTCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_PTCANFD/IPD_NKI_PTCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NKI_PTCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NKI_SFCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NKI_SFCANFD/IPD_NKI_SFCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NKI_SFCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
                    <CONTEXT-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPDEcuComp/IPD_NM_BSMtoRMS_BKPCANFD</CONTEXT-PORT-REF>
                    <TARGET-DATA-PROTOTYPE-REF DEST="VARIABLE-DATA-PROTOTYPE">/SoftwareTypes/Interfaces/IPD_NM_BSMtoRMS_BKPCANFD/IPD_NM_BSMtoRMS_BKPCANFD</TARGET-DATA-PROTOTYPE-REF>
                  </DATA-ELEMENT-IREF>
                  <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/IPD_NM_BSMtoRMS_BKPCANFD</SYSTEM-SIGNAL-REF>
                </SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                <SENDER-RECEIVER-TO-SIGNAL-MAPPING>
                  <DATA-ELEMENT-IREF>
                    <CONTEXT-COMPOSITION-REF DEST="ROOT-SW-COMPOSITION-PROTOTYPE">/System/System/IPDEcuComp</CONTEXT-COMPOSITION-REF>
