                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DircnIndLghtSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cd2b8a90cf76322ba5c16d317380e68c">
                  <SHORT-NAME>DistSinceTrgtCamr_IPD_DistSinceTrgtCamr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DistSinceTrgtCamr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DistSinceTrgtCamr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8ca41ebe716d3b769bd183521905d98e">
                  <SHORT-NAME>DistToTrfcJamNav_IPD_DistToTrfcJamNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DistToTrfcJamNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DistToTrfcJamNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="016c4999e0cc39b0b8fec706366b3a12">
                  <SHORT-NAME>DownVelocityRTK_IPD_DownVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DownVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DownVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="54859b74d0283f03a079855f4bd0ac29">
                  <SHORT-NAME>DrvTqReqWhlFilt_Nm_IPD_DrvTqReqWhlFilt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DrvTqReqWhlFilt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlFilt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7ad9f6c3ee8d30a0ab7673d56ffab7c2">
                  <SHORT-NAME>DrvTqReqWhlRawCap_Nm_IPD_DrvTqReqWhlRawCap_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DrvTqReqWhlRawCap_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlRawCap_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca9c5e15ecc73099973bf956f9f1e938">
                  <SHORT-NAME>DrvTqReqWhlRaw_Nm_IPD_DrvTqReqWhlRaw_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DrvTqReqWhlRaw_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvTqReqWhlRaw_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9d884188d8403bc588d6f352dd9d429d">
                  <SHORT-NAME>DrvrDstrctnSts_IPD_DrvrDstrctnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DrvrDstrctnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvrDstrctnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a65a148847534558a1974c012233398">
                  <SHORT-NAME>DrvrFtgLvl_IPD_DrvrFtgLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DrvrFtgLvl</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DrvrFtgLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5efa0ecaa43f3071b5eae8922150ad08">
                  <SHORT-NAME>DsblICE_flg_IPD_DsblICE_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DsblICE_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DsblICE_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f8c344027f013a439232a25b1ec95930">
                  <SHORT-NAME>DsblISG_flg_IPD_DsblISG_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DsblISG_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DsblISG_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93894c3d410036b7a7ee08eea8894ba5">
                  <SHORT-NAME>DschrgOptMaxPwr_IPD_DschrgOptMaxPwr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/DschrgOptMaxPwr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/DschrgOptMaxPwr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0790d9d446c239c387b3b10edec2fb8e">
                  <SHORT-NAME>ECM_010ms_Group00_IPD_ECM_010ms_Group00</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ECM_010ms_Group00</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_010ms_Group00</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e48da2b1112c3683931dc13158f39a1c">
                  <SHORT-NAME>ECM_25ms_Group36_IPD_ECM_25ms_Group36</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ECM_25ms_Group36</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_25ms_Group36</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4c8d54bf15b438de8b98e9ee65db5dbe">
                  <SHORT-NAME>ECM_500ms_group02_IPD_ECM_500ms_group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ECM_500ms_group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_500ms_group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3b49732665dc35b1ab7f46b2fa20391d">
                  <SHORT-NAME>ECM_ZONE_020ms_Group03_IPD_ECM_ZONE_020ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ECM_ZONE_020ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_ZONE_020ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="83bf0ff4dba83577b56892107e5bb068">
                  <SHORT-NAME>ECM_ZONE_050ms_Group09_IPD_ECM_ZONE_050ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ECM_ZONE_050ms_Group09</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ECM_ZONE_050ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8b9de2aab71037e5a69978eea83757c4">
                  <SHORT-NAME>EDUClntTemV_IPD_EDUClntTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EDUClntTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUClntTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b048516443e53064ab8375ff868374ff">
                  <SHORT-NAME>EDUClntTem_IPD_EDUClntTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EDUClntTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUClntTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1cb6eae6b63135e3a714d51afecbb80a">
                  <SHORT-NAME>EDUOilTemV_IPD_EDUOilTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EDUOilTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUOilTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="29a91527df713f64a93eb12d4ca5c333">
                  <SHORT-NAME>EDUOilTem_IPD_EDUOilTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EDUOilTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EDUOilTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87e9eab355b434c4a2fe4d0f835c9fec">
                  <SHORT-NAME>ELKDspCmd_IPD_ELKDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ELKDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb59a6a93e973e54a6d4bd2a5ce6abc4">
                  <SHORT-NAME>ELKSwReq_IPD_ELKSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ELKSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="646ce152ddbf323da836d7710c7defa6">
                  <SHORT-NAME>ELKSysFltSts_IPD_ELKSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ELKSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c19f28b733c30a091c879ae78132807">
                  <SHORT-NAME>ELKWarning_IPD_ELKWarning</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ELKWarning</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ELKWarning</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c7231b19e1983bccad42ea82f5a822a0">
                  <SHORT-NAME>EORWarningEvtSts_IPD_EORWarningEvtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EORWarningEvtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EORWarningEvtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="40c89bcea7a639aa8fd2e34491d6b2d7">
                  <SHORT-NAME>EPSAvlbly_IPD_EPSAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPSAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPSAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ec4aef3abe5d3f5c8b4f9037a64e963e">
                  <SHORT-NAME>EPSCTTX_IPD_EPSCTTX</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPSCTTX</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPSCTTX</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8dd06c912c8a3931becedf8b4c22a596">
                  <SHORT-NAME>EPS_010ms_Group03_IPD_EPS_010ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPS_010ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_010ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="38d4b71eab613579bd25c2c058f8f439">
                  <SHORT-NAME>EPS_10ms_Group01_IPD_EPS_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPS_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2caf798852663d50a697fe2f4327104f">
                  <SHORT-NAME>EPS_10ms_Group02_IPD_EPS_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPS_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5c33a86630453d5da9e619b4c7290a76">
                  <SHORT-NAME>EPS_10ms_Group05_IPD_EPS_10ms_Group05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPS_10ms_Group05</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_10ms_Group05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="73db19b4f00e3de786ef70f01276b0ae">
                  <SHORT-NAME>EPS_20ms_Group03_IPD_EPS_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPS_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPS_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="72ff0be08c8737ec805d012e904e3d84">
                  <SHORT-NAME>EPTClntPumpSta_IPD_EPTClntPumpSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPTClntPumpSta</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPTClntPumpSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e87ab6a383f3548b105036855055780">
                  <SHORT-NAME>EPTElecWtrPumpActuSpd_IPD_EPTElecWtrPumpActuSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EPTElecWtrPumpActuSpd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EPTElecWtrPumpActuSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ba5ef5992990391084dfe1eb0de3c4b2">
                  <SHORT-NAME>ERCBrkRgnPwrLmt_kW_IPD_ERCBrkRgnPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCBrkRgnPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCBrkRgnPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f5137fb25cd35cd8a679ef2fa25fc93">
                  <SHORT-NAME>ERCChrgPwrLmtPeak_kW_IPD_ERCChrgPwrLmtPeak_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCChrgPwrLmtPeak_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCChrgPwrLmtPeak_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="34119be215733f80abb1f72a8aa589f2">
                  <SHORT-NAME>ERCChrgPwrLmtWhl_kW_IPD_ERCChrgPwrLmtWhl_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCChrgPwrLmtWhl_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCChrgPwrLmtWhl_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d514fe408ebf37e58e943c6841259df2">
                  <SHORT-NAME>ERCDsChrgPwrLmtPeak_kW_IPD_ERCDsChrgPwrLmtPeak_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCDsChrgPwrLmtPeak_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCDsChrgPwrLmtPeak_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b93403cd8a9933a8a735a72b01946df4">
                  <SHORT-NAME>ERCDsChrgPwrLmtWhl_kW_IPD_ERCDsChrgPwrLmtWhl_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCDsChrgPwrLmtWhl_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCDsChrgPwrLmtWhl_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="13fd00e68866327685c1bb45b90bf800">
                  <SHORT-NAME>ERCEmgcyPwrDwn_flg_IPD_ERCEmgcyPwrDwn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCEmgcyPwrDwn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCEmgcyPwrDwn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7157cbfa40633475a8ad5c136354d78b">
                  <SHORT-NAME>ERCFCOReq_flg_IPD_ERCFCOReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCFCOReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCFCOReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2cb4cace6dcc36f7ac8bafa26bcf7824">
                  <SHORT-NAME>ERCHVAllwd_flg_IPD_ERCHVAllwd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCHVAllwd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCHVAllwd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ecf304888033d04af72a1fb4a1a88a2">
                  <SHORT-NAME>ERCHVHldReq_flg_IPD_ERCHVHldReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCHVHldReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCHVHldReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0f47264831653982ba098ea5c82a1e2e">
                  <SHORT-NAME>ERCMaxChrgPwrLmt_kW_IPD_ERCMaxChrgPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCMaxChrgPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCMaxChrgPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b84ddbf6f6de30ef8c8e3e0fe3f2ad46">
                  <SHORT-NAME>ERCMaxDschgPwrLmt_kW_IPD_ERCMaxDschgPwrLmt_kW</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ERCMaxDschgPwrLmt_kW</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ERCMaxDschgPwrLmt_kW</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a41b3765d0883dc7832f2cb46bd1b79a">
                  <SHORT-NAME>ESCLPwrSts_IPD_ESCLPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESCLPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESCLPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6da4ada0b8bb330fbe3e509c49d8bddc">
                  <SHORT-NAME>ESFStsForEdr_IPD_ESFStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESFStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESFStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="806136d3f4443edca3bead2ee817057b">
                  <SHORT-NAME>ESSAdoWrnngDspCmd_IPD_ESSAdoWrnngDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESSAdoWrnngDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSAdoWrnngDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa857217dced3e348e19cddfcbbd037f">
                  <SHORT-NAME>ESSAdoWrnngReq_IPD_ESSAdoWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESSAdoWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSAdoWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1fadc77b4d7c322fbf11ecdf04bf2e5a">
                  <SHORT-NAME>ESSDspCmd_IPD_ESSDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESSDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2ddbac725c7a30d6b7755edcc98fc3e4">
                  <SHORT-NAME>ESS_100ms_Group58_IPD_ESS_100ms_Group58</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESS_100ms_Group58</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESS_100ms_Group58</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="da761e50d1ed3f309176054d24f68bf3">
                  <SHORT-NAME>ESSswReq_IPD_ESSswReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ESSswReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ESSswReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="08b994644e903130a94e88cd06228594">
                  <SHORT-NAME>EVMd_flg_IPD_EVMd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EVMd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EVMd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a398b49af5c8383595fc1c0d0cbe9ad0">
                  <SHORT-NAME>EastVelocityRTK_IPD_EastVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EastVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EastVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="62de83dded163253b529a8ea69fe08a7">
                  <SHORT-NAME>ElecPwrDistbnScene_IPD_ElecPwrDistbnScene</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ElecPwrDistbnScene</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ElecPwrDistbnScene</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4904252a19ef37f6ad63a705e1998225">
                  <SHORT-NAME>En12VoltStrMotCmddOn_IPD_En12VoltStrMotCmddOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/En12VoltStrMotCmddOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/En12VoltStrMotCmddOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8320d333219038089f895d5349093087">
                  <SHORT-NAME>EngBrkTqMax_Nm_IPD_EngBrkTqMax_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngBrkTqMax_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngBrkTqMax_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="183e22654c31388a83abfb3fa4c5c8ca">
                  <SHORT-NAME>EngFastTqReq_Nm_IPD_EngFastTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngFastTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFastTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f59f66cf24d43302afd9f7a48c68d47b">
                  <SHORT-NAME>EngFastTqTypReq_enum_IPD_EngFastTqTypReq_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngFastTqTypReq_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFastTqTypReq_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1bd05f9e0e80304c84fdc5e217435f97">
                  <SHORT-NAME>EngFlexplateTqFstTgt_Nm_IPD_EngFlexplateTqFstTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngFlexplateTqFstTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFlexplateTqFstTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4b64a67a25443463ad1f48361430c056">
                  <SHORT-NAME>EngFlexplateTqSlowTgt_Nm_IPD_EngFlexplateTqSlowTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngFlexplateTqSlowTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngFlexplateTqSlowTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="28e05bceed26327db58ba43b376cc64d">
                  <SHORT-NAME>EngPhsAng_deg_IPD_EngPhsAng_deg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngPhsAng_deg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngPhsAng_deg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a13b0e683263aad98c1d2a4acf630d5">
                  <SHORT-NAME>EngSlowTqReq_Nm_IPD_EngSlowTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngSlowTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngSlowTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c0aa267862a3f619c0db93bf4df04fb">
                  <SHORT-NAME>EngSpdSafe4EngStrt_flg_IPD_EngSpdSafe4EngStrt_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngSpdSafe4EngStrt_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngSpdSafe4EngStrt_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="94200072516a394790c4fd64e8caa405">
                  <SHORT-NAME>EngStallCnt_cnt_IPD_EngStallCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStallCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStallCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87439718128636039f5c002f61b89e59">
                  <SHORT-NAME>EngStall_cnt_IPD_EngStall_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStall_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStall_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d43dce1c887d33efaed8688316f8e870">
                  <SHORT-NAME>EngStopReqCfmd_flg_IPD_EngStopReqCfmd_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStopReqCfmd_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStopReqCfmd_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6e14473ff4e037bc9a048d74ec2d06d7">
                  <SHORT-NAME>EngStrtDampSlipFailCnt_cnt_IPD_EngStrtDampSlipFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtDampSlipFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtDampSlipFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="08c64972f9ba31daba1f51cbb529928f">
                  <SHORT-NAME>EngStrtFailCnt_cnt_IPD_EngStrtFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e1f8c7fe9303073a3f2e6204833d8e5">
                  <SHORT-NAME>EngStrtFail_cnt_IPD_EngStrtFail_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtFail_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtFail_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f6621b2774ae3f3281be5f48e6f1b6f4">
                  <SHORT-NAME>EngStrtNoCapFailCnt_cnt_IPD_EngStrtNoCapFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtNoCapFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtNoCapFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e5d424a954063686a2b2279c66582331">
                  <SHORT-NAME>EngStrtReq_flg_IPD_EngStrtReq_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtReq_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtReq_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3ddbac05c8d3dbda4adfbaf93197906">
                  <SHORT-NAME>EngStrtStuckFailCnt_cnt_IPD_EngStrtStuckFailCnt_cnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EngStrtStuckFailCnt_cnt</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EngStrtStuckFailCnt_cnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="236c38f2451137bc97e3308e94ec8339">
                  <SHORT-NAME>EvtPotclSigIPD1_IPD_EvtPotclSigIPD1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d98deef50e79370691598fee8cdef711">
                  <SHORT-NAME>EvtPotclSigIPD2_IPD_EvtPotclSigIPD2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e1b15e0a6e333dd49712189af6508d84">
                  <SHORT-NAME>EvtPotclSigIPD3_IPD_EvtPotclSigIPD3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7a3b7aaaffef3dd2a9b1579f38869cf8">
                  <SHORT-NAME>EvtPotclSigIPD4_IPD_EvtPotclSigIPD4</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD4</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD4</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bf5c975a34a03fc3bc4edf8ab7af18aa">
                  <SHORT-NAME>EvtPotclSigIPD5_IPD_EvtPotclSigIPD5</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD5</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD5</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6360332718de3ec8b69542e62e4b494a">
                  <SHORT-NAME>EvtPotclSigIPD6_IPD_EvtPotclSigIPD6</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD6</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD6</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aa0a8d2bc4ee3ad89ad3983408db1d89">
                  <SHORT-NAME>EvtPotclSigIPD7_IPD_EvtPotclSigIPD7</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD7</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD7</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ffe1a16cbd813facb893c1bb535bb61f">
                  <SHORT-NAME>EvtPotclSigIPD8_IPD_EvtPotclSigIPD8</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/EvtPotclSigIPD8</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/EvtPotclSigIPD8</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="695db3b346703fc7b81a88b429047930">
                  <SHORT-NAME>FCTBSysFltSts_ADAS_IPD_FCTBSysFltSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTBSysFltSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTBSysFltSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed91fa8a4cf2342ba38463a6b12204c3">
                  <SHORT-NAME>FCTBSysFltSts_IPD_FCTBSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTBSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTBSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="82c7f2fa444a3087b3f8ae842bad5c96">
                  <SHORT-NAME>FCTSwSts_ADAS_IPD_FCTSwSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTSwSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSwSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="27c09e97e02e3f668ca7a5d4cb785b52">
                  <SHORT-NAME>FCTSwSts_IPD_FCTSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f644530eee323a5482154e5e405f3eae">
                  <SHORT-NAME>FCTSysFltSts_ADAS_IPD_FCTSysFltSts_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTSysFltSts_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysFltSts_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="62165da8d67e3f648311f78e13aaded9">
                  <SHORT-NAME>FCTSysFltSts_IPD_FCTSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7e8f0ea014313ed4a42db69c7877c255">
                  <SHORT-NAME>FCTSysSelReq_IPD_FCTSysSelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCTSysSelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCTSysSelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d7a0229f66c535de8a5f505f5be66246">
                  <SHORT-NAME>FCWDspCmd_IPD_FCWDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a071abd598538128a0936dc5133501a">
                  <SHORT-NAME>FCWSnstvtLvlReq_IPD_FCWSnstvtLvlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWSnstvtLvlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSnstvtLvlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89dc56a75d65332fa431806ec66d7e67">
                  <SHORT-NAME>FCWSnstvtLvl_IPD_FCWSnstvtLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWSnstvtLvl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSnstvtLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e50a55fa79034d899aec9ccf8edf815">
                  <SHORT-NAME>FCWSwReq_IPD_FCWSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a979f2d276ea3a24b0dbf5e9976a785e">
                  <SHORT-NAME>FCWSysFltSts_IPD_FCWSysFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWSysFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWSysFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c564bd8cf22e346095cca0e2308a9a8a">
                  <SHORT-NAME>FCWrnngSts_IPD_FCWrnngSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FCWrnngSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FCWrnngSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c3b4e1e30be23818b3ab8c50cd33e2f6">
                  <SHORT-NAME>FDRPwrSts_IPD_FDRPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FDRPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FDRPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="535cc981a99c34cb89b235b844833e0f">
                  <SHORT-NAME>FDR_100ms_Group01_IPD_FDR_100ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FDR_100ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FDR_100ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="012ff9287ede300fba202190b2cad7be">
                  <SHORT-NAME>FLDircnLghtSts_IPD_FLDircnLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLDircnLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDircnLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="471607d325133c939d946d2d2703731e">
                  <SHORT-NAME>FLDoorHndlPESwtActv_IPD_FLDoorHndlPESwtActv</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLDoorHndlPESwtActv</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDoorHndlPESwtActv</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="683087d1e4fd3ed7bbec72d397207ecc">
                  <SHORT-NAME>FLDoorOpenSts_IPD_FLDoorOpenSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLDoorOpenSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLDoorOpenSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c441b871692b32a78d8b9d0e6a09ce98">
                  <SHORT-NAME>FLObsRng_IPD_FLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b425e2cd1f073c73b18d2d2de93b2274">
                  <SHORT-NAME>FLSObsRng_IPD_FLSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce2b936bddd236e4950d2d6d52aa0b5e">
                  <SHORT-NAME>FLSUSSSts_IPD_FLSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7214da34263d356ca02ec3902e58e3fa">
                  <SHORT-NAME>FLSideObsRng_IPD_FLSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a3bde83b80f134c481fcc83c2a233698">
                  <SHORT-NAME>FLTirePrsV_IPD_FLTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e7d95b0dbd513d87881a53655756228f">
                  <SHORT-NAME>FLTirePrs_IPD_FLTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fd70eda1a3a83052a88893eb92a2262e">
                  <SHORT-NAME>FLTireSts_IPD_FLTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3764f03b29f93336a9b4f8ebfe69ea38">
                  <SHORT-NAME>FLTireTemV_IPD_FLTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4c2f3542dc5d36daabeb1be366bda8c2">
                  <SHORT-NAME>FLTireTem_IPD_FLTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b448ad9256d833378ff6c9af225fcfcb">
                  <SHORT-NAME>FLUSSSts_IPD_FLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="61bc2ef3a87c33efa880a29a5c4f9a22">
                  <SHORT-NAME>FLiDARPwrSts_IPD_FLiDARPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FLiDARPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FLiDARPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a5bf3ccf4b63b6ba7e91124bb5b3d02">
                  <SHORT-NAME>FMLUSSSts_IPD_FMLUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FMLUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FMLUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7374168d3cb53af4ad2cab0b2e53bd15">
                  <SHORT-NAME>FMRUSSSts_IPD_FMRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FMRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FMRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5969795131fb3581b8d53214c13465e3">
                  <SHORT-NAME>FOTAStatusValid_IPD_FOTAStatusValid</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FOTAStatusValid</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTAStatusValid</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="041156b9d25739c484e468923030d482">
                  <SHORT-NAME>FOTAStatus_IPD_FOTAStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FOTAStatus</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTAStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="330aadd49ef83371845d83a18672e914">
                  <SHORT-NAME>FOTATargetValid_IPD_FOTATargetValid</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FOTATargetValid</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTATargetValid</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="88d66e3d29b13226addde0720c812c71">
                  <SHORT-NAME>FOTATarget_IPD_FOTATarget</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FOTATarget</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FOTATarget</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb1693e3e4243efc9b536ecd4bde9cbd">
                  <SHORT-NAME>FRDircnLghtSts_IPD_FRDircnLghtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRDircnLghtSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDircnLghtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="67a2cecb3b923c3a9dbaddebc78b27a7">
                  <SHORT-NAME>FRDoorHndlPESwtActv_IPD_FRDoorHndlPESwtActv</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRDoorHndlPESwtActv</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDoorHndlPESwtActv</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8faa7686f0a8364eac7b6966f5c98a47">
                  <SHORT-NAME>FRDoorOpenSts_IPD_FRDoorOpenSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRDoorOpenSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRDoorOpenSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1dd9b52fa18531f69cc82f823a25370c">
                  <SHORT-NAME>FRObsRng_IPD_FRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6dc4cc26d9fb3305aed3ee718c60f98c">
                  <SHORT-NAME>FRSObsRng_IPD_FRSObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRSObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="14e4e496bb73387ab6cb5d51699eb08d">
                  <SHORT-NAME>FRSUSSSts_IPD_FRSUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRSUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5584b7bf73cc308081405c7001a83b1a">
                  <SHORT-NAME>FRSideObsRng_IPD_FRSideObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRSideObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRSideObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b8f100b8f0853b26bb4cab1e43b52cfe">
                  <SHORT-NAME>FRTirePrsV_IPD_FRTirePrsV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRTirePrsV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTirePrsV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="38ffd6c3682933548a01fa8f8369ef76">
                  <SHORT-NAME>FRTirePrs_IPD_FRTirePrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRTirePrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTirePrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a75d8b162b8536a58da2580b36993a78">
                  <SHORT-NAME>FRTireSts_IPD_FRTireSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRTireSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f451a0ae511d3f67a7ca2d507f47c890">
                  <SHORT-NAME>FRTireTemV_IPD_FRTireTemV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRTireTemV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireTemV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f6d663abe1bd311bbb7c8b92caca7ef5">
                  <SHORT-NAME>FRTireTem_IPD_FRTireTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRTireTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRTireTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ecd0b33f663e323c8a194488af85c036">
                  <SHORT-NAME>FRUSSSts_IPD_FRUSSSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FRUSSSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FRUSSSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7994622034a13da6a38cdc261d427450">
                  <SHORT-NAME>FVCM_10ms_Group01_IPD_FVCM_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FVCM_10ms_Group01</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FVCM_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45168a78eaac38e2a1f230c226005e17">
                  <SHORT-NAME>FVCM_20ms_Group02_IPD_FVCM_20ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FVCM_20ms_Group02</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FVCM_20ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ef0bb4259483d3eb5d71d5c3fe67fa3">
                  <SHORT-NAME>FrtCamrHeatCtrl_IPD_FrtCamrHeatCtrl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtCamrHeatCtrl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCamrHeatCtrl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b9f741d773e3769a048b83304c3da0d">
                  <SHORT-NAME>FrtCamrHeatSts_IPD_FrtCamrHeatSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtCamrHeatSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCamrHeatSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e76e546dfd243bc68629414f7e154a2e">
                  <SHORT-NAME>FrtCarGoNotfrDspCmd_IPD_FrtCarGoNotfrDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtCarGoNotfrDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCarGoNotfrDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c4f548cf4cf038fa810f6cfbacd3fdea">
                  <SHORT-NAME>FrtCarGoNotfrSwReq_IPD_FrtCarGoNotfrSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtCarGoNotfrSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtCarGoNotfrSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c2f9815af7c3350d91e7e739e492cbc1">
                  <SHORT-NAME>FrtMidLObsRng_IPD_FrtMidLObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtMidLObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtMidLObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fccbc2179bd23303bf783d3faf32455e">
                  <SHORT-NAME>FrtMidRObsRng_IPD_FrtMidRObsRng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtMidRObsRng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtMidRObsRng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="89466ee7eb2b3ef59aa6f0b45c811c6c">
                  <SHORT-NAME>FrtObsDist_IPD_FrtObsDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtObsDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtObsDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3892cf22e59b348a8ef410011113f1f8">
                  <SHORT-NAME>FrtPDCAudWrnng_IPD_FrtPDCAudWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtPDCAudWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtPDCAudWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ff2c9e27647304cbd2c5c0c633867b8">
                  <SHORT-NAME>FrtPsngDoorOpenSts_LHZCU_IPD_FrtPsngDoorOpenSts_LHZCU</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtPsngDoorOpenSts_LHZCU</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtPsngDoorOpenSts_LHZCU</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45271a3ba20f36adae6c579ca2e9a3fd">
                  <SHORT-NAME>FrtTireStdPrs_IPD_FrtTireStdPrs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtTireStdPrs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtTireStdPrs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="38da272ee34b3485a674c4be101985c3">
                  <SHORT-NAME>FrtWindShldSfcTem_IPD_FrtWindShldSfcTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtWindShldSfcTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSfcTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd82e948608530c6ab3aa36c64de7ab7">
                  <SHORT-NAME>FrtWindShldSurndHmdty_IPD_FrtWindShldSurndHmdty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtWindShldSurndHmdty</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSurndHmdty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c0213cb350683ce2bc1f2c03072b8fa8">
                  <SHORT-NAME>FrtWindShldSurndTem_IPD_FrtWindShldSurndTem</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtWindShldSurndTem</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWindShldSurndTem</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cfe97316219234dfbc0419018b60c26b">
                  <SHORT-NAME>FrtWiperSpd_IPD_FrtWiperSpd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtWiperSpd</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWiperSpd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1456984450b23903977d379807c1bb2a">
                  <SHORT-NAME>FrtWiperSwSts_IPD_FrtWiperSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FrtWiperSwSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FrtWiperSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="480c6d69bab43fc19334ac4a1ff6d90a">
                  <SHORT-NAME>FuCutReq_enum_IPD_FuCutReq_enum</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FuCutReq_enum</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FuCutReq_enum</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f9a6abb748d3c13ac3a563308208622">
                  <SHORT-NAME>FulCutDMFPrdtn_flg_IPD_FulCutDMFPrdtn_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FulCutDMFPrdtn_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutDMFPrdtn_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="60741d33ecb336f4a063d502413cd1b6">
                  <SHORT-NAME>FulCutEngStall_flg_IPD_FulCutEngStall_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FulCutEngStall_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutEngStall_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="813cd5702fb6394f8e0564c998ac528a">
                  <SHORT-NAME>FulCutLosCommWthEMS_flg_IPD_FulCutLosCommWthEMS_flg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/FulCutLosCommWthEMS_flg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/FulCutLosCommWthEMS_flg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25ca5bd85fd83c4594af3538d6b914a3">
                  <SHORT-NAME>GNSSAntennasBroken_IPD_GNSSAntennasBroken</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/GNSSAntennasBroken</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/GNSSAntennasBroken</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="813fc473a5e3386a97481a26930e2259">
                  <SHORT-NAME>GNSSAntennasInfo_IPD_GNSSAntennasInfo</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/GNSSAntennasInfo</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/GNSSAntennasInfo</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="64b26f3f43183f3087b6e1b4914bdff6">
                  <SHORT-NAME>HCUSAMTqReq_Nm_IPD_HCUSAMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HCUSAMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HCUSAMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c751b6fcaa431d0b5650c6c89b63fcd">
                  <SHORT-NAME>HORWarningEvtSts_IPD_HORWarningEvtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HORWarningEvtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HORWarningEvtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d73a1ac2a74b369caa402053e558845f">
                  <SHORT-NAME>HPPFnSts_IPD_HPPFnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HPPFnSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPFnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c9184f8604b53d68b6720401c84f4c0a">
                  <SHORT-NAME>HPPInBmtSts_IPD_HPPInBmtSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HPPInBmtSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPInBmtSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="946f9c48a7ea3d388166c392a8b80412">
                  <SHORT-NAME>HPPMapBuildSts_IPD_HPPMapBuildSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HPPMapBuildSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPMapBuildSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="579924721000322dadfd75b24abaf321">
                  <SHORT-NAME>HPPOnRoutSts_IPD_HPPOnRoutSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HPPOnRoutSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HPPOnRoutSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb78ed4cf7703f1fbba865ad4af08f3d">
                  <SHORT-NAME>HmdtySnsrHdwrFltPrst_IPD_HmdtySnsrHdwrFltPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/HmdtySnsrHdwrFltPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/HmdtySnsrHdwrFltPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c827510a360370397020fa3cab1312c">
                  <SHORT-NAME>IACCOvTSuppresCmd_IPD_IACCOvTSuppresCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IACCOvTSuppresCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCOvTSuppresCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7b0d501226c23fe7baadbeef48a2185c">
                  <SHORT-NAME>IACCOvTSuppresSwReq_IPD_IACCOvTSuppresSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IACCOvTSuppresSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCOvTSuppresSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="daa03df0520c3dc5a36d34a9ec4bcafd">
                  <SHORT-NAME>IACCPreMsgReq_IPD_IACCPreMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IACCPreMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="df464814ccd73f1b8d62ea4f16dbb887">
                  <SHORT-NAME>IACCPreSpdLimtCmd_IPD_IACCPreSpdLimtCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IACCPreSpdLimtCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreSpdLimtCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="56c1b7100d9937ebb2f2f188132ce977">
                  <SHORT-NAME>IACCPreSpdLimtSwReq_IPD_IACCPreSpdLimtSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IACCPreSpdLimtSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IACCPreSpdLimtSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e480f17cedc93e868714dc491eff7ba3">
                  <SHORT-NAME>IAMAvlbly_IPD_IAMAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAMAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAMAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f27f56408b243a5fb05dc100c19bd4c2">
                  <SHORT-NAME>IAMReststs_IPD_IAMReststs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAMReststs</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAMReststs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d83031303003d8bb5b51bbf2f1a2adb">
                  <SHORT-NAME>IAM_100ms_Group08_IPD_IAM_100ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_100ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e96336fd83ab3656bd1b9c54843d8c03">
                  <SHORT-NAME>IAM_100ms_Group18_IPD_IAM_100ms_Group18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_100ms_Group18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="298374644faa353295be921fcfbf3ef5">
                  <SHORT-NAME>IAM_100ms_Group56_IPD_IAM_100ms_Group56</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_100ms_Group56</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_100ms_Group56</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c82d29f1c613948b00f029bb72dba4a">
                  <SHORT-NAME>IAM_20ms_Group32_IPD_IAM_20ms_Group32</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_20ms_Group32</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_20ms_Group32</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed2eed981bb03a33bb5138ec823c5d68">
                  <SHORT-NAME>IAM_ZONE_100ms_Group13_IPD_IAM_ZONE_100ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_ZONE_100ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="30ae64ed2951370faaa0584ace2c3e31">
                  <SHORT-NAME>IAM_ZONE_100ms_Group34_IPD_IAM_ZONE_100ms_Group34</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_ZONE_100ms_Group34</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group34</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7b8400e244b33bcebc8e3275ca526adf">
                  <SHORT-NAME>IAM_ZONE_100ms_Group35_IPD_IAM_ZONE_100ms_Group35</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_ZONE_100ms_Group35</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group35</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0b0ca505edeb3d39a7413e5b5b6395d0">
                  <SHORT-NAME>IAM_ZONE_100ms_Group40_IPD_IAM_ZONE_100ms_Group40</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_ZONE_100ms_Group40</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group40</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e01d7ea5ab6e37368d929d10749c9362">
                  <SHORT-NAME>IAM_ZONE_100ms_Group57_IPD_IAM_ZONE_100ms_Group57</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IAM_ZONE_100ms_Group57</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IAM_ZONE_100ms_Group57</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a9b4c533173f37b89ea8a1006429237b">
                  <SHORT-NAME>IBS_100ms_Group15_IPD_IBS_100ms_Group15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_100ms_Group15</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_100ms_Group15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="af75be592cea385b94732b9bcea06ebb">
                  <SHORT-NAME>IBS_10ms_Group01_IPD_IBS_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ff8c89542b4f3a84ba18355f189d1d8f">
                  <SHORT-NAME>IBS_10ms_Group02_IPD_IBS_10ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_10ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="083661328e383d33b24c3e0889f9edb8">
                  <SHORT-NAME>IBS_10ms_Group04_IPD_IBS_10ms_Group04</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_10ms_Group04</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_10ms_Group04</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b11ecd77ca1938c3927e309be75234d9">
                  <SHORT-NAME>IBS_20ms_Group07_IPD_IBS_20ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group07</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4fc617ed9dab3dd097ebc0694c89f03a">
                  <SHORT-NAME>IBS_20ms_Group08_IPD_IBS_20ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="074de953d2da3b23a6cfb6d5b3ca8d8e">
                  <SHORT-NAME>IBS_20ms_Group09_IPD_IBS_20ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group09</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d95179e4c69f300ba3125c35ad91dab8">
                  <SHORT-NAME>IBS_20ms_Group10_IPD_IBS_20ms_Group10</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group10</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group10</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="75cb815f0fdf3453be24b42607f74dae">
                  <SHORT-NAME>IBS_20ms_Group11_IPD_IBS_20ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b47e9524e2693d49acc503816fad4f2f">
                  <SHORT-NAME>IBS_20ms_Group12_IPD_IBS_20ms_Group12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group12</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d335419872a83cd0ba1f55a3897175a9">
                  <SHORT-NAME>IBS_20ms_Group13_IPD_IBS_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_20ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e54cc414f9f3b43b825abb992006319">
                  <SHORT-NAME>IBS_CHAvlbly_IPD_IBS_CHAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_CHAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_CHAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e6607ab9b4f347ba9abca41d74a3cff">
                  <SHORT-NAME>IBS_ZONE_20ms_Group08_IPD_IBS_ZONE_20ms_Group08</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IBS_ZONE_20ms_Group08</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IBS_ZONE_20ms_Group08</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="478aa2bf16553cc7803826be4c89def1">
                  <SHORT-NAME>ICBAD_100ms_Group25_IPD_ICBAD_100ms_Group25</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_100ms_Group25</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_100ms_Group25</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a042f7264df35cc803a27ba873380bd">
                  <SHORT-NAME>ICBAD_100ms_Group37_IPD_ICBAD_100ms_Group37</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_100ms_Group37</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_100ms_Group37</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d03a2abbd7c53b9a80521077d239e4b1">
                  <SHORT-NAME>ICBAD_10ms_Group01_IPD_ICBAD_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_10ms_Group01</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="802331fcf9db36dcaa648511e95b0638">
                  <SHORT-NAME>ICBAD_20ms_Group05_IPD_ICBAD_20ms_Group05</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group05</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group05</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="98efbf1e7d0f301ca8ec99d7155f16a9">
                  <SHORT-NAME>ICBAD_20ms_Group07_IPD_ICBAD_20ms_Group07</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group07</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group07</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9b7b185b74b23f3abdb1fb92a7973f38">
                  <SHORT-NAME>ICBAD_20ms_Group09_IPD_ICBAD_20ms_Group09</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group09</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group09</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="65d471cf982f3c1da9d11f7507286bba">
                  <SHORT-NAME>ICBAD_20ms_Group12_IPD_ICBAD_20ms_Group12</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group12</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group12</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4883255adf5f3073b73d2201d590617f">
                  <SHORT-NAME>ICBAD_20ms_Group13_IPD_ICBAD_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group13</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9a67e014970732e9a8c665cd69be7bea">
                  <SHORT-NAME>ICBAD_20ms_Group15_IPD_ICBAD_20ms_Group15</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group15</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group15</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="04d5c45499c63d778f32d24216428446">
                  <SHORT-NAME>ICBAD_20ms_Group46_IPD_ICBAD_20ms_Group46</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group46</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group46</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f20a947f68537f8ba235cfdb7c017bc">
                  <SHORT-NAME>ICBAD_20ms_Group48_IPD_ICBAD_20ms_Group48</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_20ms_Group48</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_20ms_Group48</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bb75649fe64a34daa767334b132df2da">
                  <SHORT-NAME>ICBAD_ZONE_10ms_Group20_IPD_ICBAD_ZONE_10ms_Group20</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_ZONE_10ms_Group20</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_ZONE_10ms_Group20</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a7e986530273feb91d31805ada95f40">
                  <SHORT-NAME>ICBAD_ZONE_20ms_Group13_IPD_ICBAD_ZONE_20ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBAD_ZONE_20ms_Group13</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBAD_ZONE_20ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d5a86bb505f38b4b17d1e8e7479bb45">
                  <SHORT-NAME>ICBVC_100ms_Group01_IPD_ICBVC_100ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_100ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0384c12d169e31cf99f79cfde13a0b48">
                  <SHORT-NAME>ICBVC_100ms_Group19_IPD_ICBVC_100ms_Group19</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_100ms_Group19</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group19</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="594df6d5ea21398687928003b00a7ac3">
                  <SHORT-NAME>ICBVC_100ms_Group80_IPD_ICBVC_100ms_Group80</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_100ms_Group80</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_100ms_Group80</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1de56657a4cb3241bf30b926676bdd03">
                  <SHORT-NAME>ICBVC_200ms_Group79_IPD_ICBVC_200ms_Group79</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_200ms_Group79</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_200ms_Group79</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d1485e0eb1f36129ab6f7505a08ada0">
                  <SHORT-NAME>ICBVC_20ms_Group03_IPD_ICBVC_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78b03f4c670637ff8ad240ba43e25598">
                  <SHORT-NAME>ICBVC_50ms_Group11_IPD_ICBVC_50ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_50ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ecdc65d5f6f63dc4995b5cf99a79f8eb">
                  <SHORT-NAME>ICBVC_50ms_Group13_IPD_ICBVC_50ms_Group13</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_50ms_Group13</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group13</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0a0fe690def53573b29dee3c74ebd992">
                  <SHORT-NAME>ICBVC_50ms_Group158_IPD_ICBVC_50ms_Group158</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_50ms_Group158</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group158</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e66a27cd53b332f1b1350476ee3d41d7">
                  <SHORT-NAME>ICBVC_50ms_Group256_IPD_ICBVC_50ms_Group256</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICBVC_50ms_Group256</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICBVC_50ms_Group256</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7d512eae6f073ff48607cebc2a5c705b">
                  <SHORT-NAME>ICMDrvrDstcnSts_IPD_ICMDrvrDstcnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMDrvrDstcnSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrDstcnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3068626e97eb3dfbb45ad4e38bf4e6e7">
                  <SHORT-NAME>ICMDrvrFtgLvl_IPD_ICMDrvrFtgLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMDrvrFtgLvl</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrFtgLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d10738ce6d33f60ad2bb1d6d6423a77">
                  <SHORT-NAME>ICMDrvrPrst_IPD_ICMDrvrPrst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMDrvrPrst</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMDrvrPrst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bfc00450797032c2949ccccf61db01a6">
                  <SHORT-NAME>ICMEyeOnRoad_IPD_ICMEyeOnRoad</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMEyeOnRoad</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMEyeOnRoad</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="11ac62420f9431bd96112a465d556de7">
                  <SHORT-NAME>ICMSwReq_Reserve16_IPD_ICMSwReq_Reserve16</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMSwReq_Reserve16</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMSwReq_Reserve16</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a4af95c2b70c3af3968f6ba2ed32414d">
                  <SHORT-NAME>ICMSwReq_Reserve17_IPD_ICMSwReq_Reserve17</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ICMSwReq_Reserve17</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ICMSwReq_Reserve17</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c6eb112b23623ebd9d6cc280ed11e2ae">
                  <SHORT-NAME>ILCSwReq_IPD_ILCSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ILCSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ILCSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="36d1de69d42039a28b558998c780b670">
                  <SHORT-NAME>IMM_50ms_Group02_IPD_IMM_50ms_Group02</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IMM_50ms_Group02</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IMM_50ms_Group02</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3bc1f15657733540990d006effee17ef">
                  <SHORT-NAME>IMU_SN_IPD_IMU_SN</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IMU_SN</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IMU_SN</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3597aac71e333c7ba866d84d9b9527aa">
                  <SHORT-NAME>IPDAVCamrHeatReq_IPD_IPDAVCamrHeatReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDAVCamrHeatReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAVCamrHeatReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b818dfc2a2a830d2bcb0665b16e8dd59">
                  <SHORT-NAME>IPDAlgFlag_IPD_IPDAlgFlag</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDAlgFlag</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAlgFlag</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="53e3b523ed1534b38b2ab37662c270cc">
                  <SHORT-NAME>IPDAurixTemp_IPD_IPDAurixTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDAurixTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDAurixTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="86e7f926fa2b3dd786958236e9fdbbc5">
                  <SHORT-NAME>IPDComKeyEnbResp_IPD_IPDComKeyEnbResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDComKeyEnbResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDComKeyEnbResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7cba756c06e53dfeb3c49241287f6cb9">
                  <SHORT-NAME>IPDDataId_IPD_IPDDataId</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDDataId</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDDataId</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="51e633a88c653959aa91119b057804a0">
                  <SHORT-NAME>IPDErrorCount_IPD_IPDErrorCount</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDErrorCount</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDErrorCount</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5e1e2691a9f43358b1b9c84be8e013f5">
                  <SHORT-NAME>IPDFailedReason_IPD_IPDFailedReason</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDFailedReason</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDFailedReason</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b772f8d6705f3028bd6641d93a937dcd">
                  <SHORT-NAME>IPDIdentityResp_IPD_IPDIdentityResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDIdentityResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDIdentityResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f915885ac2f732d9b26ee107e46ed36b">
                  <SHORT-NAME>IPDKeyStatus_IPD_IPDKeyStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDKeyStatus</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDKeyStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dffa8b4f2ef03eab95196f929b2a3d08">
                  <SHORT-NAME>IPDMCUTemp_IPD_IPDMCUTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDMCUTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDMCUTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78b4b3da5f753d58aa6238c5933d4a3f">
                  <SHORT-NAME>IPDPCBTemp1_IPD_IPDPCBTemp1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDPCBTemp1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPCBTemp1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0bae3429f63433779b39aba217a8226f">
                  <SHORT-NAME>IPDPCBTemp2_IPD_IPDPCBTemp2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDPCBTemp2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPCBTemp2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fa3f9162909f376c8bf8d519caea6332">
                  <SHORT-NAME>IPDPMICTemp_IPD_IPDPMICTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDPMICTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPMICTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f40a10d82c2e3505919d5efda9e9330a">
                  <SHORT-NAME>IPDPowerFailSwReq_IPD_IPDPowerFailSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDPowerFailSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDPowerFailSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6fe92c3fa227327092f58f113384c21f">
                  <SHORT-NAME>IPDResetCnt_IPD_IPDResetCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDResetCnt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDResetCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b71122b1f28f323596bffc2aec832fb4">
                  <SHORT-NAME>IPDSOCTemp_IPD_IPDSOCTemp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDSOCTemp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDSOCTemp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6388ddb676553936ab28244ad1ce69c8">
                  <SHORT-NAME>IPDStsResp_IPD_IPDStsResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDStsResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDStsResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c2bd6bd0b4735e28b14e54377d531bc">
                  <SHORT-NAME>IPDThermalWrnngLvl_IPD_IPDThermalWrnngLvl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDThermalWrnngLvl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDThermalWrnngLvl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="16f8d4bfc1c63626a93537e3e16f0c23">
                  <SHORT-NAME>IPDTripCntResetResp_IPD_IPDTripCntResetResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDTripCntResetResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripCntResetResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b74c08bad38c3ffead04dabe30ce9bc9">
                  <SHORT-NAME>IPDTripCnt_IPD_IPDTripCnt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDTripCnt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripCnt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cb9aabd4b6b63874a230384b381851a3">
                  <SHORT-NAME>IPDTripNvmTag_IPD_IPDTripNvmTag</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDTripNvmTag</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDTripNvmTag</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="065140a7a426392c9cbfeb26afd7a934">
                  <SHORT-NAME>IPDWtrClntInltFlwReq_IPD_IPDWtrClntInltFlwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDWtrClntInltFlwReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltFlwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3e91bf5d8218373faee3afec377b48e9">
                  <SHORT-NAME>IPDWtrClntInltReqFlg_IPD_IPDWtrClntInltReqFlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDWtrClntInltReqFlg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltReqFlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d85a1de1a1dd379296f88b2562bfa804">
                  <SHORT-NAME>IPDWtrClntInltTimeReq_IPD_IPDWtrClntInltTimeReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPDWtrClntInltTimeReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPDWtrClntInltTimeReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0155344fa31839d38f67e86eeb5f0ec8">
                  <SHORT-NAME>IPD_20ms_Group43_IPD_IPD_20ms_Group43</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_20ms_Group43</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group43</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="25cecb28d3003ca99558636aa7d73644">
                  <SHORT-NAME>IPD_20ms_Group60_IPD_IPD_20ms_Group60</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_20ms_Group60</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group60</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="896bcac51ee53f6b97e2e346f30fd0f6">
                  <SHORT-NAME>IPD_20ms_Group64_IPD_IPD_20ms_Group64</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_20ms_Group64</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group64</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e5018b38730c34d1b380c8c878667dc6">
                  <SHORT-NAME>IPD_20ms_Group67_IPD_IPD_20ms_Group67</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_20ms_Group67</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_20ms_Group67</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="19a85458be513c03bb0db1e488840819">
                  <SHORT-NAME>IPD_50ms_Group14_IPD_IPD_50ms_Group14</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_50ms_Group14</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_50ms_Group14</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca93241b09933f6e97bbd00acd16e470">
                  <SHORT-NAME>IPD_50ms_Group49_IPD_IPD_50ms_Group49</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_50ms_Group49</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_50ms_Group49</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1bf8afe4828c3bb8be2cd1ad11f689ba">
                  <SHORT-NAME>IPD_NKI_BKPCANFD_IPD_IPD_NKI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NKI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7fe0ab31f1d53be3b89c97a90e0cfc95">
                  <SHORT-NAME>IPD_NKI_CHCANFD_IPD_IPD_NKI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NKI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="295b58a4194f3666be183e66d55ceca3">
                  <SHORT-NAME>IPD_NKI_PTCANFD_IPD_IPD_NKI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NKI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="088de1f7098c3839b7abdde3a456b3c4">
                  <SHORT-NAME>IPD_NKI_SFCANFD_IPD_IPD_NKI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NKI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NKI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8c4805474c263f4898a34d917a4c1d26">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_BKPCANFD_IPD_IPD_NM_BSMtoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_BSMtoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6a432bdb5d663623803804850bfdf24f">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_CHCANFD_IPD_IPD_NM_BSMtoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_BSMtoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2a947183e14d3e3da8fdb9e8e79f7ed6">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_PTCANFD_IPD_IPD_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_BSMtoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a128c4076a5f3d1ba34048472339ae41">
                  <SHORT-NAME>IPD_NM_BSMtoRMS_SFCANFD_IPD_IPD_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_BSMtoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_BSMtoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2bec98e72cc7394084a53a743069a5f7">
                  <SHORT-NAME>IPD_NM_NOSSta_BKPCANFD_IPD_IPD_NM_NOSSta_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOSSta_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="400fc30336473bf996b0e751cb456ce6">
                  <SHORT-NAME>IPD_NM_NOSSta_CHCANFD_IPD_IPD_NM_NOSSta_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOSSta_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78056f1011993a76b3b86a418965da75">
                  <SHORT-NAME>IPD_NM_NOSSta_PTCANFD_IPD_IPD_NM_NOSSta_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOSSta_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ab282d0a3df13bab810ae0456c7bfc9e">
                  <SHORT-NAME>IPD_NM_NOSSta_SFCANFD_IPD_IPD_NM_NOSSta_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOSSta_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOSSta_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9dd4407c2abd34cdbe3abf328fbe1bbc">
                  <SHORT-NAME>IPD_NM_NOStoRMS_BKPCANFD_IPD_IPD_NM_NOStoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOStoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="eb731742a07535eaa7d9340d7909cc4d">
                  <SHORT-NAME>IPD_NM_NOStoRMS_CHCANFD_IPD_IPD_NM_NOStoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOStoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="062dbe9447c03fa8af5eaa73bb6b5857">
                  <SHORT-NAME>IPD_NM_NOStoRMS_PTCANFD_IPD_IPD_NM_NOStoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOStoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="579a93fa4e923c71a5db901b38192b41">
                  <SHORT-NAME>IPD_NM_NOStoRMS_SFCANFD_IPD_IPD_NM_NOStoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_NOStoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_NOStoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d542f0c0be4435fa80ffd07065ec3784">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_BKPCANFD_IPD_IPD_NM_PBSMtoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_PBSMtoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="87ac5f23e0bd38ec9dad68eaad6f54ba">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_CHCANFD_IPD_IPD_NM_PBSMtoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_PBSMtoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4a2c96cfacbf33e69a98d70d965abc63">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_PTCANFD_IPD_IPD_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_PBSMtoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="221f734528333ecd9df3479ef47903ea">
                  <SHORT-NAME>IPD_NM_PBSMtoRMS_SFCANFD_IPD_IPD_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_PBSMtoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_PBSMtoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aae1d702f5bd374ebd04f3d2a15641f3">
                  <SHORT-NAME>IPD_NM_RMSSta_BKPCANFD_IPD_IPD_NM_RMSSta_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMSSta_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d7d11372e20d3fada5562318036077f9">
                  <SHORT-NAME>IPD_NM_RMSSta_CHCANFD_IPD_IPD_NM_RMSSta_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMSSta_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4a26019323603b74bf69fcabcc2fcc40">
                  <SHORT-NAME>IPD_NM_RMSSta_PTCANFD_IPD_IPD_NM_RMSSta_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMSSta_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="506fdc28dafe3b51b8ec821b8b940215">
                  <SHORT-NAME>IPD_NM_RMSSta_SFCANFD_IPD_IPD_NM_RMSSta_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMSSta_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMSSta_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5e88857c5793c69bbdddbbda70614be">
                  <SHORT-NAME>IPD_NM_RMStoNOS_BKPCANFD_IPD_IPD_NM_RMStoNOS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMStoNOS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5355b9022ce43eb5bb34d60c2f8c5bd0">
                  <SHORT-NAME>IPD_NM_RMStoNOS_CHCANFD_IPD_IPD_NM_RMStoNOS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMStoNOS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="43f9744418883a8a96077fe80e0557f1">
                  <SHORT-NAME>IPD_NM_RMStoNOS_PTCANFD_IPD_IPD_NM_RMStoNOS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMStoNOS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5b13d797a6693fb3bf81e56c1a05994e">
                  <SHORT-NAME>IPD_NM_RMStoNOS_SFCANFD_IPD_IPD_NM_RMStoNOS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RMStoNOS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RMStoNOS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cbbff79052de3fb3a0a42a838cfd4b81">
                  <SHORT-NAME>IPD_NM_RSStoNOS_BKPCANFD_IPD_IPD_NM_RSStoNOS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoNOS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5c795c8af563f0685923d30ee6ef6b3">
                  <SHORT-NAME>IPD_NM_RSStoNOS_CHCANFD_IPD_IPD_NM_RSStoNOS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoNOS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3d711e318453d74b3da56528b2c746a">
                  <SHORT-NAME>IPD_NM_RSStoNOS_PTCANFD_IPD_IPD_NM_RSStoNOS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoNOS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="675fec5ad3c236e6bda32d0b5a4570d1">
                  <SHORT-NAME>IPD_NM_RSStoNOS_SFCANFD_IPD_IPD_NM_RSStoNOS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoNOS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoNOS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a708d21e36f43a65a369d6155f6720c2">
                  <SHORT-NAME>IPD_NM_RSStoRMS_BKPCANFD_IPD_IPD_NM_RSStoRMS_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoRMS_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="95a6d71b35e537db869fffe225132107">
                  <SHORT-NAME>IPD_NM_RSStoRMS_CHCANFD_IPD_IPD_NM_RSStoRMS_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoRMS_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f599ce3686bc330bb5a9fcf645100b97">
                  <SHORT-NAME>IPD_NM_RSStoRMS_PTCANFD_IPD_IPD_NM_RSStoRMS_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoRMS_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="96697396a13e39e8b78f44b270cef117">
                  <SHORT-NAME>IPD_NM_RSStoRMS_SFCANFD_IPD_IPD_NM_RSStoRMS_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NM_RSStoRMS_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NM_RSStoRMS_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a3017beda833305985196b0253ad85c6">
                  <SHORT-NAME>IPD_NOI_BKPCANFD_IPD_IPD_NOI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NOI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d90bdb92c7d3c32bc6d235d6eb46b62">
                  <SHORT-NAME>IPD_NOI_CHCANFD_IPD_IPD_NOI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NOI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6c21d69c675a3f26a3ecccc64b447d7b">
                  <SHORT-NAME>IPD_NOI_PTCANFD_IPD_IPD_NOI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NOI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fbf87ef8dd553c49a44492c6f5e9076c">
                  <SHORT-NAME>IPD_NOI_SFCANFD_IPD_IPD_NOI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NOI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NOI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9fd9110837893440959a56ddbe5245a1">
                  <SHORT-NAME>IPD_NWI_BKPCANFD_IPD_IPD_NWI_BKPCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NWI_BKPCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_BKPCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ef11b0604053724a84fa5104a023cbd">
                  <SHORT-NAME>IPD_NWI_CHCANFD_IPD_IPD_NWI_CHCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NWI_CHCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_CHCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6dc0f3cc7f133e5b96d40f1e064ac53c">
                  <SHORT-NAME>IPD_NWI_PTCANFD_IPD_IPD_NWI_PTCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NWI_PTCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_PTCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0239b77943f4347981b7b84c9f167eb4">
                  <SHORT-NAME>IPD_NWI_SFCANFD_IPD_IPD_NWI_SFCANFD</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_NWI_SFCANFD</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_NWI_SFCANFD</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="19ca6021e1e634df83bc57186dfd7b85">
                  <SHORT-NAME>IPD_Sporadic_TimeSync_Group_IPD_IPD_Sporadic_TimeSync_Group</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_Sporadic_TimeSync_Group</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_Sporadic_TimeSync_Group</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="29058613a8043ecd9da7efd8f1149b5e">
                  <SHORT-NAME>IPD_VehLckCtrlReq_IPD_IPD_VehLckCtrlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IPD_VehLckCtrlReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD_VehLckCtrlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c20698309e993cef84ae4acf1322a2af">
                  <SHORT-NAME>ISGMaxTqLmt_Nm_IPD_ISGMaxTqLmt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ISGMaxTqLmt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGMaxTqLmt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f2303c55c6f23eb28d6280a7f7b3ce3b">
                  <SHORT-NAME>ISGMinTqLmt_Nm_IPD_ISGMinTqLmt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ISGMinTqLmt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGMinTqLmt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2b4ab1cf30023c708e252428f69c35e2">
                  <SHORT-NAME>ISGTqTgt_Nm_IPD_ISGTqTgt_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ISGTqTgt_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ISGTqTgt_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="490fc1f3f3ac39efb567e44317e68670">
                  <SHORT-NAME>IdentityChlg_IPD_IdentityChlg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IdentityChlg</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IdentityChlg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e1cec79fe3243847ac296f7bd8f0578d">
                  <SHORT-NAME>IgnOffTimeV_IPD_IgnOffTimeV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IgnOffTimeV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IgnOffTimeV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c869a64a32b53c0db464b6564e86fbc3">
                  <SHORT-NAME>IgnOffTime_IPD_IgnOffTime</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/IgnOffTime</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IgnOffTime</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2625d53319623b4a82e678ad58c62a24">
                  <SHORT-NAME>JAMsgReq_IPD_JAMsgReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/JAMsgReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/JAMsgReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="db17a2561e3936debe280b1acf1273c4">
                  <SHORT-NAME>LADSCurToEndPntDist_IPD_LADSCurToEndPntDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LADSCurToEndPntDist</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LADSCurToEndPntDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="48876d84d48c300a8a422fdffafcb0dd">
                  <SHORT-NAME>LADSInfoDispReqToICM_HPP_IPD_LADSInfoDispReqToICM_HPP</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LADSInfoDispReqToICM_HPP</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LADSInfoDispReqToICM_HPP</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d5e200d91ca3d489b4d82932a0ba5bd">
                  <SHORT-NAME>LCASelReq_IPD_LCASelReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LCASelReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCASelReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c5b610eee6a83597a13a9236bdbf69cf">
                  <SHORT-NAME>LCRInHMI_IPD_LCRInHMI</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LCRInHMI</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRInHMI</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e963ef09f48e38cab846b7f41fba7fe7">
                  <SHORT-NAME>LCRSwDspCmd_IPD_LCRSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LCRSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="377ff64705043a73befe26d18c371866">
                  <SHORT-NAME>LCRSwReq_IPD_LCRSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LCRSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LCRSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="96044f98347a3b028f5a54f470a50d0a">
                  <SHORT-NAME>LDWAdoWrnngReq_IPD_LDWAdoWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LDWAdoWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWAdoWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8af8222be3153c32844c951de7d1c8a9">
                  <SHORT-NAME>LDWLKAHptWrnngReq_IPD_LDWLKAHptWrnngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LDWLKAHptWrnngReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWLKAHptWrnngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93ef8b5266b73ee6a8836f8ac886eb7d">
                  <SHORT-NAME>LDWLKASwReq_IPD_LDWLKASwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LDWLKASwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWLKASwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0640c751a9cb3fadbff04b85a4eeb69a">
                  <SHORT-NAME>LDWSnstvtLvlReq_IPD_LDWSnstvtLvlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LDWSnstvtLvlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWSnstvtLvlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="66e4cbe255db33be822e92f49b19935e">
                  <SHORT-NAME>LDWStsForEdr_IPD_LDWStsForEdr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LDWStsForEdr</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LDWStsForEdr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="68e35e8cc989338c9673ba89ec501896">
                  <SHORT-NAME>LFCTWrnng_ADAS_IPD_LFCTWrnng_ADAS</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LFCTWrnng_ADAS</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LFCTWrnng_ADAS</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c680d0e818d3dd0b1bb4fec90f23eb6">
                  <SHORT-NAME>LFCTWrnng_IPD_LFCTWrnng</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LFCTWrnng</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LFCTWrnng</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="13a416c1d2fe3cd3af842973e476c7a4">
                  <SHORT-NAME>LHSWPwrSts_IPD_LHSWPwrSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHSWPwrSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHSWPwrSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="83aba2bd23db3355a17ca2d165fc0a25">
                  <SHORT-NAME>LHZCUAvlbly_IPD_LHZCUAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCUAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCUAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="02dd7a0710c0364dbc305bc4d976ddd6">
                  <SHORT-NAME>LHZCU_100ms_Group30_IPD_LHZCU_100ms_Group30</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_100ms_Group30</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_100ms_Group30</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ca76b106f6734c196fdc46a4fd78531">
                  <SHORT-NAME>LHZCU_10ms_Group01_IPD_LHZCU_10ms_Group01</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_10ms_Group01</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_10ms_Group01</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4357da044fca316a8c338c9cd4486280">
                  <SHORT-NAME>LHZCU_10ms_Group32_IPD_LHZCU_10ms_Group32</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_10ms_Group32</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_10ms_Group32</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dc635150579d350cbb52e4a26fb4e613">
                  <SHORT-NAME>LHZCU_20ms_Group03_IPD_LHZCU_20ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_20ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_20ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="247b0c1ae1af3eafbfa74f664c402b01">
                  <SHORT-NAME>LHZCU_400ms_Group18_IPD_LHZCU_400ms_Group18</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_400ms_Group18</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_400ms_Group18</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5d7f739b2add3ad89e6fc5448e29682c">
                  <SHORT-NAME>LHZCU_50ms_Group06_IPD_LHZCU_50ms_Group06</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_50ms_Group06</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_50ms_Group06</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b215b11d0fc13fb29a4d1612cfa21073">
                  <SHORT-NAME>LHZCU_50ms_Group24_IPD_LHZCU_50ms_Group24</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/LHZCU_50ms_Group24</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/LHZCU_50ms_Group24</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="978ef7fd59f03dc7a28182cb7003d27b">
                  <SHORT-NAME>Lane0_C0_IPD_Lane0_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="53ffcb8eace13a29a5ab981e2ef18bbf">
                  <SHORT-NAME>Lane0_C1_IPD_Lane0_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3ad6561dedf334adbd29f7e6ed22b130">
                  <SHORT-NAME>Lane0_C2_IPD_Lane0_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3e2d64076e5f325c87a2902e59635a45">
                  <SHORT-NAME>Lane0_C3_IPD_Lane0_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="10ab7156b8cb30738eedfe9d1a72984c">
                  <SHORT-NAME>Lane0_ExistPrblty_IPD_Lane0_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="69ee3938163934f4ab9b357a7d519ede">
                  <SHORT-NAME>Lane0_ID_IPD_Lane0_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c3a6cd63c54c343bb7923c7c176b3cc0">
                  <SHORT-NAME>Lane0_MarkerColor_IPD_Lane0_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ed2fb6caf8f83a498ce1977813986c87">
                  <SHORT-NAME>Lane0_MarkerType_IPD_Lane0_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d9b4b86eb763763a1f774b52ae76d3a">
                  <SHORT-NAME>Lane0_Part0_SyncFrameIndex_IPD_Lane0_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8d29189343ca3b68bf3948abea3dd0d9">
                  <SHORT-NAME>Lane0_ViewRangeEnd_IPD_Lane0_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a2525a45020338879b24633440cc1902">
                  <SHORT-NAME>Lane0_ViewRangeStart_IPD_Lane0_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b5ae0d6025f631b5af6ddb44a88071b4">
                  <SHORT-NAME>Lane0_location_IPD_Lane0_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane0_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane0_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fb29efea1af732049733666b4724d062">
                  <SHORT-NAME>Lane1_C0_IPD_Lane1_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="62abd7379f1c394091eba7b42d3e26f3">
                  <SHORT-NAME>Lane1_C1_IPD_Lane1_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="32140b953222358688b52ee35abcd7f7">
                  <SHORT-NAME>Lane1_C2_IPD_Lane1_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d8514367beab316baf53dc6ae0c2c8c2">
                  <SHORT-NAME>Lane1_C3_IPD_Lane1_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="76baaea779fc38e7a4bde946ca4ac331">
                  <SHORT-NAME>Lane1_ExistPrblty_IPD_Lane1_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="98c9684c508233b6bc43caa9f7827d93">
                  <SHORT-NAME>Lane1_ID_IPD_Lane1_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e442a875cd43584a6fedb1645e53e17">
                  <SHORT-NAME>Lane1_MarkerColor_IPD_Lane1_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7de1ee34be7a35bb8c2c2307e4b3d54d">
                  <SHORT-NAME>Lane1_MarkerType_IPD_Lane1_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a0c6eb2a14993f65bd19950b953baa06">
                  <SHORT-NAME>Lane1_Part0_SyncFrameIndex_IPD_Lane1_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="146896ba97d4386eb30535974792dc32">
                  <SHORT-NAME>Lane1_ViewRangeEnd_IPD_Lane1_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="499e893eacf837929107d82d387852fd">
                  <SHORT-NAME>Lane1_ViewRangeStart_IPD_Lane1_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="de2aabe2f83337888cb1bfdd793d94e6">
                  <SHORT-NAME>Lane1_location_IPD_Lane1_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane1_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane1_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d7e0b7d25a833f5c9b2289d3a93a3575">
                  <SHORT-NAME>Lane2_C0_IPD_Lane2_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9105aa0311e035f996bf155092a808e5">
                  <SHORT-NAME>Lane2_C1_IPD_Lane2_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f597df22e2e63d16931fd6fa192608c4">
                  <SHORT-NAME>Lane2_C2_IPD_Lane2_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="578e7d70133f3701bec5dedb4982ac8d">
                  <SHORT-NAME>Lane2_C3_IPD_Lane2_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="740690abd09f376cb2747ac0e6546f41">
                  <SHORT-NAME>Lane2_ExistPrblty_IPD_Lane2_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d88d7a44b94c3b2783066f332ce448f9">
                  <SHORT-NAME>Lane2_ID_IPD_Lane2_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="58055c88ad4730cda956e35418d766bb">
                  <SHORT-NAME>Lane2_MarkerColor_IPD_Lane2_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4408ef85e22f337c9eda6da8748647a4">
                  <SHORT-NAME>Lane2_MarkerType_IPD_Lane2_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fdb32818fd1039a385ede861ed8b44b3">
                  <SHORT-NAME>Lane2_Part0_SyncFrameIndex_IPD_Lane2_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d546b362138738cbadf537524681f820">
                  <SHORT-NAME>Lane2_ViewRangeEnd_IPD_Lane2_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="539b3e52f7af3c9c8acc0a96cf919d57">
                  <SHORT-NAME>Lane2_ViewRangeStart_IPD_Lane2_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2f9eae1e14b63bdebdb2d56be8726781">
                  <SHORT-NAME>Lane2_location_IPD_Lane2_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane2_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane2_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fdd072c36ac9343383b0e6cbd88bd2f8">
                  <SHORT-NAME>Lane3_C0_IPD_Lane3_C0</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_C0</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C0</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ec54b4e6ad273d07bcd3dffe5ef19874">
                  <SHORT-NAME>Lane3_C1_IPD_Lane3_C1</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_C1</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C1</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b58cbd738dc3354699216cdf89b2774d">
                  <SHORT-NAME>Lane3_C2_IPD_Lane3_C2</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_C2</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C2</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd90436256ed37c39390c97de2dd555a">
                  <SHORT-NAME>Lane3_C3_IPD_Lane3_C3</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_C3</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_C3</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0f301d47e55031f3a8df43ff6d5c1806">
                  <SHORT-NAME>Lane3_ExistPrblty_IPD_Lane3_ExistPrblty</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_ExistPrblty</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ExistPrblty</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="dd3a2916a21b37a7a015760efab67dd9">
                  <SHORT-NAME>Lane3_ID_IPD_Lane3_ID</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_ID</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ID</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fd08a34d5c293f71a9fc3d5e289b078a">
                  <SHORT-NAME>Lane3_MarkerColor_IPD_Lane3_MarkerColor</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_MarkerColor</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_MarkerColor</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="993b39d5cd123b0780e48c53c5e1630c">
                  <SHORT-NAME>Lane3_MarkerType_IPD_Lane3_MarkerType</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_MarkerType</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_MarkerType</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="503ed6cfe12e3fef9041a3af66b7ae95">
                  <SHORT-NAME>Lane3_Part0_SyncFrameIndex_IPD_Lane3_Part0_SyncFrameIndex</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_Part0_SyncFrameIndex</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_Part0_SyncFrameIndex</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="03daba86f6de3c9a95b62d25dde40005">
                  <SHORT-NAME>Lane3_ViewRangeEnd_IPD_Lane3_ViewRangeEnd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_ViewRangeEnd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ViewRangeEnd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2714e6fffc6a33119eb94de44444acbe">
                  <SHORT-NAME>Lane3_ViewRangeStart_IPD_Lane3_ViewRangeStart</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_ViewRangeStart</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_ViewRangeStart</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="85972a5a6a963c52a60cbccf0a60e041">
                  <SHORT-NAME>Lane3_location_IPD_Lane3_location</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/Lane3_location</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/Lane3_location</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="99b975ebfa7a307ebd9a8cd14126e26b">
                  <SHORT-NAME>MONSAMTqReq_Nm_IPD_MONSAMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MONSAMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MONSAMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="96ca8b32e61a3261a15b10245c93e67b">
                  <SHORT-NAME>MONTMTqReq_Nm_IPD_MONTMTqReq_Nm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MONTMTqReq_Nm</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MONTMTqReq_Nm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7c20c7bf9f3c3f38b38feadb8480c418">
                  <SHORT-NAME>MainBeamLghtOn_IPD_MainBeamLghtOn</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MainBeamLghtOn</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MainBeamLghtOn</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="938a1c480cf83a64b8da712ff1fa585a">
                  <SHORT-NAME>MemParkngBtnRcnm_IPD_MemParkngBtnRcnm</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MemParkngBtnRcnm</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemParkngBtnRcnm</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="61350716d74a37fcae29c5d141f8db65">
                  <SHORT-NAME>MemPkngSlntPtrlEnbSwReq_IPD_MemPkngSlntPtrlEnbSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MemPkngSlntPtrlEnbSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemPkngSlntPtrlEnbSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0cb685763ff937c0a348bd7e62c16081">
                  <SHORT-NAME>MemPkngSwReq_IPD_MemPkngSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MemPkngSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MemPkngSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fc5047bbdafa3b5ab19bbb5c2b542fc0">
                  <SHORT-NAME>MnvrngPntDistNav_IPD_MnvrngPntDistNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MnvrngPntDistNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MnvrngPntDistNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c2c04dc3b69f3078a6e3129bd6647dfc">
                  <SHORT-NAME>MnvrngPntTypNav_IPD_MnvrngPntTypNav</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/MnvrngPntTypNav</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/MnvrngPntTypNav</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="49e7346e3f2f378085e5d6f5178dd195">
                  <SHORT-NAME>NOACitySysMsg_IPD_NOACitySysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOACitySysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOACitySysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6d9ac2ca730f38829140add6bd7e8e94">
                  <SHORT-NAME>NOADistDecMsg_IPD_NOADistDecMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOADistDecMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOADistDecMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1a874465dfbd35e0bee60c877afd7810">
                  <SHORT-NAME>NOAETCSetDspCmd_IPD_NOAETCSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAETCSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAETCSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8624fd639df733be862bd538d7133428">
                  <SHORT-NAME>NOAETCSetSwReq_IPD_NOAETCSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAETCSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAETCSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5db82694a01e33c19cb6f39cbf88d2c4">
                  <SHORT-NAME>NOALaneSetDspCmd_IPD_NOALaneSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOALaneSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOALaneSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5ba1fc78c62933b1bce4ffdbcdd9a013">
                  <SHORT-NAME>NOALaneSetSwReq_IPD_NOALaneSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOALaneSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOALaneSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3cfa192a47b3bd4ac46361a4f88579d">
                  <SHORT-NAME>NOAQukChgSwDspCmd_IPD_NOAQukChgSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAQukChgSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAQukChgSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7f21580a3a6030899467930945ae5b05">
                  <SHORT-NAME>NOAQukChgSwReq_IPD_NOAQukChgSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAQukChgSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAQukChgSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="da1c131ada973cc79a8b7a35f5f4682f">
                  <SHORT-NAME>NOAReportSetDspCmd_IPD_NOAReportSetDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAReportSetDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAReportSetDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9f88d84733653e5295eda72d5534bbe4">
                  <SHORT-NAME>NOAReportSetSwReq_IPD_NOAReportSetSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOAReportSetSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOAReportSetSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="448e29239d723f75ab1efd8697f2597f">
                  <SHORT-NAME>NOPCitySwDspCmd_IPD_NOPCitySwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOPCitySwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPCitySwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="20deb82ea23937909e36140efb458d88">
                  <SHORT-NAME>NOPCitySwReq_IPD_NOPCitySwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOPCitySwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPCitySwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="12608965a2fd3ec9a1e323de01063d9d">
                  <SHORT-NAME>NOPSwDspCmd_IPD_NOPSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOPSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="edbceb08c0463021b4019c277e92d37a">
                  <SHORT-NAME>NOPSwReq_IPD_NOPSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOPSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c89ef99faca631dcb8bbdbbef9313020">
                  <SHORT-NAME>NOPSysMsg_IPD_NOPSysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NOPSysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NOPSysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0af9d30362c8391e88d3e28c3adf436d">
                  <SHORT-NAME>NarRoVslAssQuit_IPD_NarRoVslAssQuit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarRoVslAssQuit</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssQuit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f1aadf356bf03add8f4497bec99c024e">
                  <SHORT-NAME>NarRoVslAssSwReq_IPD_NarRoVslAssSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarRoVslAssSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d34c0e7babfe31b78a6eb0be18f710d3">
                  <SHORT-NAME>NarRoVslAssSwResp_IPD_NarRoVslAssSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarRoVslAssSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarRoVslAssSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="79586133135930ca8863b503ef1ecd86">
                  <SHORT-NAME>NarrowRoadBackwardSts_IPD_NarrowRoadBackwardSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarrowRoadBackwardSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarrowRoadBackwardSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d2ede799b97a3d30825059f8df66ec7f">
                  <SHORT-NAME>NarrowRoadForwardSts_IPD_NarrowRoadForwardSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarrowRoadForwardSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarrowRoadForwardSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e24b796e0a6b38159c0aff2757a19dd3">
                  <SHORT-NAME>NarwSpcAstBtnSts_IPD_NarwSpcAstBtnSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarwSpcAstBtnSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstBtnSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0c1cffb7cd43303287611a271cc02324">
                  <SHORT-NAME>NarwSpcAstSwReq_IPD_NarwSpcAstSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarwSpcAstSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="47b88b40492b332390030935a4bb2ff2">
                  <SHORT-NAME>NarwSpcAstSwSts_IPD_NarwSpcAstSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NarwSpcAstSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NarwSpcAstSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="571881d24c5d32f7b6e129e8afbc485f">
                  <SHORT-NAME>NavCndSpdLmtVal_IPD_NavCndSpdLmtVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavCndSpdLmtVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCndSpdLmtVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9e146b11cee43206b7215368f232c5ec">
                  <SHORT-NAME>NavCrntRoadTyp_IPD_NavCrntRoadTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavCrntRoadTyp</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCrntRoadTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8f674af4a75632e1a28ce5083d0f6205">
                  <SHORT-NAME>NavCtryCode_ISO_IPD_NavCtryCode_ISO</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavCtryCode_ISO</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavCtryCode_ISO</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ac472b2bd12b33a9838fdc9a9f90e81e">
                  <SHORT-NAME>NavDistFromFrtEleccEye_IPD_NavDistFromFrtEleccEye</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavDistFromFrtEleccEye</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavDistFromFrtEleccEye</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="78a8e396695834afab828cf138a6e57a">
                  <SHORT-NAME>NavItvalSpdDetnDistRetDist_IPD_NavItvalSpdDetnDistRetDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavItvalSpdDetnDistRetDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavItvalSpdDetnDistRetDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="e8136f4dde783d239a641199e1adf296">
                  <SHORT-NAME>NavNewIconDist_IPD_NavNewIconDist</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavNewIconDist</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavNewIconDist</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3a60ff6ad4f1371289399e6a8db50853">
                  <SHORT-NAME>NavNextRampOffset_IPD_NavNextRampOffset</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavNextRampOffset</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavNextRampOffset</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2eefac19d535391e8008b820c909a249">
                  <SHORT-NAME>NavSpdLmtTyp_IPD_NavSpdLmtTyp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavSpdLmtTyp</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtTyp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ada186c82fb4358fa63e739049ebd880">
                  <SHORT-NAME>NavSpdLmtValSts_IPD_NavSpdLmtValSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavSpdLmtValSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtValSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="760da3271f10328fa693afa943a92f16">
                  <SHORT-NAME>NavSpdLmtValUnit_IPD_NavSpdLmtValUnit</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavSpdLmtValUnit</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtValUnit</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d5adb523fdfb32c69f09386318194179">
                  <SHORT-NAME>NavSpdLmtVal_IPD_NavSpdLmtVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavSpdLmtVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSpdLmtVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="74fd36fad2133d66810e2cbf52f610aa">
                  <SHORT-NAME>NavSts_IPD_NavSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NavSts</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NavSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0888748fe4aa3539b4a3ee076ca71ffb">
                  <SHORT-NAME>NonDirectDMSSwDspCmd_IPD_NonDirectDMSSwDspCmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NonDirectDMSSwDspCmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSwDspCmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c94b540141de3d58837d2613415125a8">
                  <SHORT-NAME>NonDirectDMSSwReq_IPD_NonDirectDMSSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NonDirectDMSSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7064e18cf76b379a8e157d7d62432a2f">
                  <SHORT-NAME>NonDirectDMSSysSts_IPD_NonDirectDMSSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NonDirectDMSSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NonDirectDMSSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c838254746ce3bf1aeaf18f973bf21bd">
                  <SHORT-NAME>NorthVelocityRTK_IPD_NorthVelocityRTK</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NorthVelocityRTK</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NorthVelocityRTK</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="76dde8a6ec213f678ba9e9ecee22c8bd">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwDscmd_IPD_NrwroadBwdAssConfrmSwDscmd</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadBwdAssConfrmSwDscmd</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssConfrmSwDscmd</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="790b64824ef435c68b0350e2a6e40570">
                  <SHORT-NAME>NrwroadBwdAssConfrmSwReq_IPD_NrwroadBwdAssConfrmSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadBwdAssConfrmSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssConfrmSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="33c568a631dc39198c2f1052fcc1f39b">
                  <SHORT-NAME>NrwroadBwdAssMesg_IPD_NrwroadBwdAssMesg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadBwdAssMesg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssMesg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="aef4c98273dc3ea09ebe9723c152bf46">
                  <SHORT-NAME>NrwroadBwdAssSwReq_IPD_NrwroadBwdAssSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadBwdAssSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6787a94c3aa537e99b53a65c297ddaae">
                  <SHORT-NAME>NrwroadBwdAssSwSts_IPD_NrwroadBwdAssSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadBwdAssSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadBwdAssSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6768526ff2083c09bb89e3fbc9a8ac00">
                  <SHORT-NAME>NrwroadFwdBtnDsp_IPD_NrwroadFwdBtnDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdBtnDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdBtnDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5b8ce11643dd30c4ae5121dae1feea3c">
                  <SHORT-NAME>NrwroadFwdCndNotSt_IPD_NrwroadFwdCndNotSt</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdCndNotSt</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdCndNotSt</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a2e151a40c25349e96127944904ef45a">
                  <SHORT-NAME>NrwroadFwdCtlReq_IPD_NrwroadFwdCtlReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdCtlReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdCtlReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ebc705ee75c139d6853ca44fd349596a">
                  <SHORT-NAME>NrwroadFwdDsp_IPD_NrwroadFwdDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d0c7c4e473eb3864a5d14a49fa78ee9e">
                  <SHORT-NAME>NrwroadFwdDst360Req_IPD_NrwroadFwdDst360Req</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDst360Req</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDst360Req</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="62c482796aa0306e8b53dd2ae57dace9">
                  <SHORT-NAME>NrwroadFwdDstBtnDsp_IPD_NrwroadFwdDstBtnDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDstBtnDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstBtnDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="35273d51fa64359592df622c8f4530f2">
                  <SHORT-NAME>NrwroadFwdDstL_IPD_NrwroadFwdDstL</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDstL</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstL</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="cc6bb36e20f33a3c8dae0cfcd701be78">
                  <SHORT-NAME>NrwroadFwdDstR_IPD_NrwroadFwdDstR</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDstR</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstR</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ef75887ae75532eb9b24ff922b949443">
                  <SHORT-NAME>NrwroadFwdDstTostDsp_IPD_NrwroadFwdDstTostDsp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdDstTostDsp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdDstTostDsp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d07627d4201737508d3f2c63d00dc5b6">
                  <SHORT-NAME>NrwroadFwdReDst_IPD_NrwroadFwdReDst</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdReDst</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdReDst</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0428da2a7fd93e83ac6a0b25b7bc6ef9">
                  <SHORT-NAME>NrwroadFwdReq_IPD_NrwroadFwdReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="59ce053846ab3837a655f29cd740614c">
                  <SHORT-NAME>NrwroadFwdSta_IPD_NrwroadFwdSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdSta</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bd390bd2b71e35fa85a26aad8c88956b">
                  <SHORT-NAME>NrwroadFwdSwSts_IPD_NrwroadFwdSwSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadFwdSwSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadFwdSwSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="9673b451bd7631a193f2c45d597b0369">
                  <SHORT-NAME>NrwroadsltReq_IPD_NrwroadsltReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadsltReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadsltReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="921e2bbd24573aafa1f17f95555807d9">
                  <SHORT-NAME>NrwroadsltSta_IPD_NrwroadsltSta</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/NrwroadsltSta</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/NrwroadsltSta</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a99337254d7f3e649f93d4d3235a2e0a">
                  <SHORT-NAME>OnBdChrgrOptAltPwr_IPD_OnBdChrgrOptAltPwr</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/OnBdChrgrOptAltPwr</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OnBdChrgrOptAltPwr</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5a930fa5978b3de2a5704de5bd6d2e64">
                  <SHORT-NAME>OtsdAirTemCrValMsk_IPD_OtsdAirTemCrValMsk</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/OtsdAirTemCrValMsk</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrValMsk</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d14bfe8c2fb93db2be98cae9ea41f91f">
                  <SHORT-NAME>OtsdAirTemCrValV_IPD_OtsdAirTemCrValV</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/OtsdAirTemCrValV</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrValV</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d01521dc7aeb3b3e9da015086251be86">
                  <SHORT-NAME>OtsdAirTemCrVal_IPD_OtsdAirTemCrVal</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/OtsdAirTemCrVal</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/OtsdAirTemCrVal</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="26d0520e0e9a3728a5afbc6ea43a866c">
                  <SHORT-NAME>PDCSysSts_IPD_PDCSysSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PDCSysSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PDCSysSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bc4145037d4f3b4cad48220a003c0d78">
                  <SHORT-NAME>PDSysKeyPsAvlbl_IPD_PDSysKeyPsAvlbl</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PDSysKeyPsAvlbl</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PDSysKeyPsAvlbl</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="502a50909a603d458cf4337b255473f7">
                  <SHORT-NAME>PEBSts_IPD_PEBSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PEBSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="65fbcddceeae3c5382cb5c642ce2e061">
                  <SHORT-NAME>PEBSwReq_IPD_PEBSwReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PEBSwReq</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSwReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="57381eed204a31708bbbd5c4738510bf">
                  <SHORT-NAME>PEBSwResp_IPD_PEBSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PEBSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="807a5b7695c93dd4920e26f7253067d9">
                  <SHORT-NAME>PEBWarngReq_IPD_PEBWarngReq</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PEBWarngReq</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEBWarngReq</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6412b0eaee433dfdb8e5ad5c0a792248">
                  <SHORT-NAME>PEU_10ms_Group25_IPD_PEU_10ms_Group25</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PEU_10ms_Group25</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PEU_10ms_Group25</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c4b18a6c346321cbaae4babfd390aff">
                  <SHORT-NAME>PICU_10ms_Group03_IPD_PICU_10ms_Group03</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PICU_10ms_Group03</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_10ms_Group03</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="91ceb8cdda4630c5996129d4c1c10eaf">
                  <SHORT-NAME>PICU_10ms_Group23_IPD_PICU_10ms_Group23</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PICU_10ms_Group23</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_10ms_Group23</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="c43d8e2965e33384ad5d1a5206167c91">
                  <SHORT-NAME>PICU_20ms_Group11_IPD_PICU_20ms_Group11</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PICU_20ms_Group11</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_20ms_Group11</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="0d6bb36bb5273cdb9eb27101341aa3a9">
                  <SHORT-NAME>PICU_PTAvlbly_IPD_PICU_PTAvlbly</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PICU_PTAvlbly</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PICU_PTAvlbly</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="47eb9791461535968ba52a8ddee5c00e">
                  <SHORT-NAME>ParkngDirAvlSts_IPD_ParkngDirAvlSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngDirAvlSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirAvlSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4f58b9559df73469976abe14991828bd">
                  <SHORT-NAME>ParkngDirSwResp_IPD_ParkngDirSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngDirSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="32bda5c10c643e7eb21f034bbcf79740">
                  <SHORT-NAME>ParkngDirSw_IPD_ParkngDirSw</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngDirSw</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngDirSw</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1d6a03bbb1213b7ea30fda79378b5155">
                  <SHORT-NAME>ParkngEndDis_IPD_ParkngEndDis</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngEndDis</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngEndDis</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="4d01c0f2b82c3aa0be4f0031d9630614">
                  <SHORT-NAME>ParkngInPrgs_IPD_ParkngInPrgs</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngInPrgs</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngInPrgs</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6e27020e65863faeb2619ad66c3940ef">
                  <SHORT-NAME>ParkngNCPAvlSts_IPD_ParkngNCPAvlSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngNCPAvlSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngNCPAvlSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2cab92332f7a3420ad8e46863519c2a3">
                  <SHORT-NAME>ParkngOutBkCrsSts_IPD_ParkngOutBkCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutBkCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7895ee33e08e37ca9c2ea0f0637c2288">
                  <SHORT-NAME>ParkngOutBkLCrsSts_IPD_ParkngOutBkLCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutBkLCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkLCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="93413637802b3a30a799edb54dda84da">
                  <SHORT-NAME>ParkngOutBkRCrsSts_IPD_ParkngOutBkRCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutBkRCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutBkRCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ace45279b895383e801fa3c3a9bbf4ff">
                  <SHORT-NAME>ParkngOutDircnSelResult_IPD_ParkngOutDircnSelResult</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutDircnSelResult</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutDircnSelResult</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="5735a6ac77213620b84856965ec759db">
                  <SHORT-NAME>ParkngOutFLCrsSts_IPD_ParkngOutFLCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutFLCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFLCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7447d2a5ea8837ad9efecb9d8b5b03f0">
                  <SHORT-NAME>ParkngOutFLParllSts_IPD_ParkngOutFLParllSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutFLParllSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFLParllSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="3fa6767a6dd93ec6b96c2c71eaf3d49d">
                  <SHORT-NAME>ParkngOutFRCrsSts_IPD_ParkngOutFRCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutFRCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFRCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c9ffd48f5a63742beff4091580c997f">
                  <SHORT-NAME>ParkngOutFRParllSts_IPD_ParkngOutFRParllSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutFRParllSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFRParllSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1c888cd7fad3370ab4e45978a1805f07">
                  <SHORT-NAME>ParkngOutFrtCrsSts_IPD_ParkngOutFrtCrsSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngOutFrtCrsSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngOutFrtCrsSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a18b54b69e563bc08430f4eb155e9dcd">
                  <SHORT-NAME>ParkngSlotFindSts_IPD_ParkngSlotFindSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngSlotFindSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngSlotFindSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="d3f8ae0ed33030c2bdb3583c5683b658">
                  <SHORT-NAME>ParkngSpdSwResp_IPD_ParkngSpdSwResp</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/ParkngSpdSwResp</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/ParkngSpdSwResp</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ca24543beeb731b7835c4ca6fe225430">
                  <SHORT-NAME>PilotSysADASFltSts_IPD_PilotSysADASFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysADASFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysADASFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ce96cfc904933536aee159a9b6b99705">
                  <SHORT-NAME>PilotSysAVCamrF1FltSts_IPD_PilotSysAVCamrF1FltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrF1FltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrF1FltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="fdaa72d86d17369ab2051f6303b8d32c">
                  <SHORT-NAME>PilotSysAVCamrF3FltSts_IPD_PilotSysAVCamrF3FltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrF3FltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrF3FltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ac7c963b465d3e0b85e98b072afab472">
                  <SHORT-NAME>PilotSysAVCamrFLSFltSts_IPD_PilotSysAVCamrFLSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrFLSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrFLSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bb4bef03384237f1864c55c19dbee279">
                  <SHORT-NAME>PilotSysAVCamrFRSFltSts_IPD_PilotSysAVCamrFRSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrFRSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrFRSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="7fca7bb655543b8dae24f17279779468">
                  <SHORT-NAME>PilotSysAVCamrRFltSts_IPD_PilotSysAVCamrRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="1cbe3a12d10f3d6facb1c7ceb9feedd4">
                  <SHORT-NAME>PilotSysAVCamrRLSFltSts_IPD_PilotSysAVCamrRLSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrRLSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRLSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="b7ddf5a6e93738a09733cbbd641e7943">
                  <SHORT-NAME>PilotSysAVCamrRRSFltSts_IPD_PilotSysAVCamrRRSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysAVCamrRRSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysAVCamrRRSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="45f7e60e56b03251b8958fb78d5fdc0c">
                  <SHORT-NAME>PilotSysFDRFltSts_IPD_PilotSysFDRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysFDRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysFDRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="704ea972532e3e6194444b0116fb113a">
                  <SHORT-NAME>PilotSysFLIDARFltSts_IPD_PilotSysFLIDARFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysFLIDARFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysFLIDARFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6ef2e5642148380e80364ebb72d98e9c">
                  <SHORT-NAME>PilotSysHDAVMCamrFFltSts_IPD_PilotSysHDAVMCamrFFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysHDAVMCamrFFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrFFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="ff2c7247ee1f3cabb6bc69bd0c0379f4">
                  <SHORT-NAME>PilotSysHDAVMCamrLHFltSts_IPD_PilotSysHDAVMCamrLHFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysHDAVMCamrLHFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrLHFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="2e962c4c59923f55b24beb4863f365a8">
                  <SHORT-NAME>PilotSysHDAVMCamrRFltSts_IPD_PilotSysHDAVMCamrRFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysHDAVMCamrRFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrRFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f12faebe0d9a371183953c6237c08c05">
                  <SHORT-NAME>PilotSysHDAVMCamrRHFltSts_IPD_PilotSysHDAVMCamrRHFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysHDAVMCamrRHFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysHDAVMCamrRHFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="536f05f5e4d63cfe8a112a6222d3f54e">
                  <SHORT-NAME>PilotSysLFSDAFltSts_IPD_PilotSysLFSDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysLFSDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysLFSDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="8fe3a02e289232a3b4f8828d04f39db7">
                  <SHORT-NAME>PilotSysLHRDAFltSts_IPD_PilotSysLHRDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysLHRDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysLHRDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="f93150edfe8d32088600e249379fb18f">
                  <SHORT-NAME>PilotSysMsg_IPD_PilotSysMsg</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysMsg</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysMsg</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="200476ebd23f3232b7c4983a343d51b5">
                  <SHORT-NAME>PilotSysRFSDAFltSts_IPD_PilotSysRFSDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysRFSDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysRFSDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="6396b6c70714313a9302ef64ad442539">
                  <SHORT-NAME>PilotSysRHRDAFltSts_IPD_PilotSysRHRDAFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysRHRDAFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysRHRDAFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="bd93d34fb0a636c6b9aca3770073b771">
                  <SHORT-NAME>PilotSysUSSFltSts_IPD_PilotSysUSSFltSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PilotSysUSSFltSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PilotSysUSSFltSts</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="35d72df4125d3fbf99f7157ee51c2800">
                  <SHORT-NAME>PosALCFailed_IPD_PosALCFailed</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PosALCFailed</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PosALCFailed</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="a5d3fbdf34b43e0b93a24011d5d37297">
                  <SHORT-NAME>PositionAttitudeStatus_IPD_PositionAttitudeStatus</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <R-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-R-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PositionAttitudeStatus</TARGET-R-PORT-REF>
                    </R-PORT-IN-COMPOSITION-INSTANCE-REF>
                  </INNER-PORT-IREF>
                  <OUTER-PORT-REF DEST="R-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/PositionAttitudeStatus</OUTER-PORT-REF>
                </DELEGATION-SW-CONNECTOR>
                <DELEGATION-SW-CONNECTOR UUID="be0efcb6d35a3203911fd03563736169">
                  <SHORT-NAME>PrvOutSts_IPD_PrvOutSts</SHORT-NAME>
                  <INNER-PORT-IREF>
                    <P-PORT-IN-COMPOSITION-INSTANCE-REF>
                      <CONTEXT-COMPONENT-REF DEST="SW-COMPONENT-PROTOTYPE">/SoftwareTypes/ComponentTypes/MComposition/IPD</CONTEXT-COMPONENT-REF>
                      <TARGET-P-PORT-REF DEST="P-PORT-PROTOTYPE">/SoftwareTypes/ComponentTypes/IPD/PrvOutSts</TARGET-P-PORT-REF>
                    </P-PORT-IN-COMPOSITION-INSTANCE-REF>
