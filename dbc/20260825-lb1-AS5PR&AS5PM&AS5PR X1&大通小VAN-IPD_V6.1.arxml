                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4d1c4c5570ca32b2a15c7a6965d76ad0">
                      <SHORT-NAME>SOCMd_enum_SOCMd_enum_SOCMd_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fa15c76d99f036b7919f901beaffe88f">
                      <SHORT-NAME>SeatOccptnNum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="a68ae944ca8939f4a5c2f61b496e0b34">
                      <SHORT-NAME>ShftSeqStat_enum_ShftSeqStat_enum_ShftSeqStat_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="eadda7e5b3983d969cbf707ae307e39c">
                      <SHORT-NAME>StrtTypAvail_enum_StrtTypAvail_enum_StrtTypAvail_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="99282100eb353dbc86ecbda73d472144">
                      <SHORT-NAME>TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_TASSAMTqSplt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3a4c1ab5276b350a91146aeb7ec9af0b">
                      <SHORT-NAME>TASTMTqSplt_Nm_TASTMTqSplt_Nm_TASTMTqSplt_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2bd1deda26283e33bd1f292dbf9ef95c">
                      <SHORT-NAME>TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_TCUIntvSAMTq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="4f09fa2b85d937868a9ecec3cec1c0d4">
                      <SHORT-NAME>TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_TCUIntvTMTq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="139ff64eb4b03490ac5b569d11fb3786">
                      <SHORT-NAME>TCUOpSt_enum_TCUOpSt_enum_TCUOpSt_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="890759e4d5723149a171b8ec67939635">
                      <SHORT-NAME>TDM_200ms_Group01_CRC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="45d1dcfd85713863bf9ec7b740780247">
                      <SHORT-NAME>TDM_200ms_Group01_RC_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="89b479e7c18c3ef0aa81dd93ba39eac6">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved103_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="ed78efae6eb03f8c8ea1d50552cc0292">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved111_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="9e8330d2449d3dba82a9553bcd164fa2">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved119_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="7bc0903bbc43345bba15b77d8634f2a7">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved127_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e919aa30aee23b4c9e88956fe39e6a68">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved15_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e3f0b98799e8358e8313360bf19ca0ce">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved27_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="695febfbdbcd3622885ff6a8905150ec">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved39_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="2d90330e33ff37328d3e92ea426ead53">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved47_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="639a5121130a36a2ba9736f5762992ee">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved55_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c8ba59d8c4bc3a9985e46f87e64cf0fc">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved63_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="75673bb52cfe320fbfa18ddc9cf9c097">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved71_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b2a08709726f35ac8cc9276f3a0451e6">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved79_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d73bfb9fdfa93c74ac6db002651ba3a3">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved87_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6d54f8caf9bb34a68c33074c3dcbd059">
                      <SHORT-NAME>TDM_200ms_Group01_Reserved95_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="3ce9cc5fd13a3812905775a523cdc5ec">
                      <SHORT-NAME>TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-PDU-PORT UUID="a7be926206c83a1d9a9cec8630f83ded">
                      <SHORT-NAME>TDM_200ms_PDU01_IPD_SFCANFD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-PDU-PORT>
                    <FRAME-PORT UUID="a69dafeff62d31559d998d43d8449a26">
                      <SHORT-NAME>TDM_SFCANFD_200ms_FrP01_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <FRAME-PORT UUID="a891b1022adc34f8ba47de8373d11544">
                      <SHORT-NAME>TDM_SFCANFD_NM_IPD</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </FRAME-PORT>
                    <I-SIGNAL-PORT UUID="cd8e920f191f3ea2bfd2809ee4fb8a59">
                      <SHORT-NAME>TPMSF_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="d3cd31d7249a3ff2ae8be711e04f24f1">
                      <SHORT-NAME>TPMSTirePrsLowIO_LHZCU_400ms_Group18_LHZCU_400ms_Group18_LHZCU_400ms_Group18_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="6699de03cd7330108abae24e596bd8b1">
                      <SHORT-NAME>TQRTMTqReq_N_TQRTMTqReq_N_TQRTMTqReq_N_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="24ebf68f160a36589777e7d7731877e8">
                      <SHORT-NAME>TRCEMTqReq_Nm_TRCEMTqReq_Nm_TRCEMTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="fca2848c87203084ab89e76a45f5f94d">
                      <SHORT-NAME>TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_TRCTqDmdSTC_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="f532b50c6d3a3c9aacff92cd6906ca3a">
                      <SHORT-NAME>TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_TZXEMMaxTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="272ce757612c308db949d62c0cf06504">
                      <SHORT-NAME>TZXEMTqReq_Nm_TZXEMTqReq_Nm_TZXEMTqReq_Nm_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="e6f7b76aec6d3e6297c2223ab2f4530d">
                      <SHORT-NAME>TqCtrlStat_enum_TqCtrlStat_enum_TqCtrlStat_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="5f8718b93b403a4ba935465b45face67">
                      <SHORT-NAME>TrlrCnctSts_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="065478467d1f3b2ab3014ad04d492648">
                      <SHORT-NAME>VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_VDCSlipCtrlSts_enum_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="b8f94321cb1a3f3482dd8b6c555d440a">
                      <SHORT-NAME>VehCrshTyp_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                    <I-SIGNAL-PORT UUID="c493c45a57a53e41a23cc055e0beeb30">
                      <SHORT-NAME>VehSideLghtSts_TDM_TDM_200ms_Group01_TDM_200ms_Group01_TDM_200ms_Group01_IPD_SFCANFD_in</SHORT-NAME>
                      <COMMUNICATION-DIRECTION>IN</COMMUNICATION-DIRECTION>
                    </I-SIGNAL-PORT>
                  </ECU-COMM-PORT-INSTANCES>
                </CAN-COMMUNICATION-CONNECTOR>
              </CONNECTORS>
              <SLEEP-MODE-SUPPORTED>false</SLEEP-MODE-SUPPORTED>
              <WAKE-UP-OVER-BUS-SUPPORTED>false</WAKE-UP-OVER-BUS-SUPPORTED>
            </ECU-INSTANCE>
          </ELEMENTS>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>