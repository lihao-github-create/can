                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeFs3Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317132XOa505a3f19f25843c4b31713100">
              <SHORT-NAME>IRZCUeSw10DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eSwitch10 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeSw10DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw10DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeSw10DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317151XOa505a3f19f25843c4b31715000">
              <SHORT-NAME>IRZCUeSw10Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eSwitch10 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeSw10Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw10Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeSw10Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3172e6XOa505a3f19f25843c4b3172e500">
              <SHORT-NAME>IRZCUeSw9DiagSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eSwitch9 Diagnostic Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeSw9DiagSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw9DiagSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeSw9DiagSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b316fdbXOa505a3f19f25843c4b316fda00">
              <SHORT-NAME>IRZCUeSw9Sts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RZCU eSwitch9 Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:
发送方描述:null
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:null</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RZCUeSw9Sts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RZCUeSw9Sts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RZCUeSw9Sts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b316bb9XOa505a3f19f25843c4b316bb800">
              <SHORT-NAME>IRainClsWndAppMsg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rain Close Window App reminder msg</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:QM
信息安全:
有无服务标签:
发送方描述:雨天自动关窗手机App消息推送通知信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:电动窗</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RainClsWndAppMsg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RainClsWndAppMsg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RainClsWndAppMsg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3760a7XOa505a3f19f25843c4b3760a600">
              <SHORT-NAME>IRdundtHybCmddEnToqImmd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Redundant Hybrid Commanded Engine Torque Immediate</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:PICU_20ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RdundtHybCmddEnToqImmd</SHORT-LABEL>
                  <VALUE>0x6a0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqImmd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqImmd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3760c2XOa505a3f19f25843c4b3760c100">
              <SHORT-NAME>IRdundtHybCmddEnToqPrdtd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Redundant Hybrid Commanded Engine Torque Predicted</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:PICU_20ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RdundtHybCmddEnToqPrdtd</SHORT-LABEL>
                  <VALUE>0x6a0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqPrdtd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqPrdtd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3766b9XOa505a3f19f25843c4b3766b800">
              <SHORT-NAME>IRdundtHybCmddEnToqRespTyp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Redundant Hybrid Commanded Engine Torque Response Type</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:PICU_20ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RdundtHybCmddEnToqRespTyp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RdundtHybCmddEnToqRespTyp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RdundtHybCmddEnToqRespTyp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c7a2XOa505a3f19f25843c4b34c7a100">
              <SHORT-NAME>IReAxleMaxAvlblWhlDrvTq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Maximum  Available  Wheel Drive Torque</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PEU_10ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:后轴最大可用驱动扭矩
接收方描述:后轴最大可用驱动扭矩
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ReAxleMaxAvlblWhlDrvTq</SHORT-LABEL>
                  <VALUE>0x7FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlDrvTq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlDrvTq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c7beXOa505a3f19f25843c4b34c7bd00">
              <SHORT-NAME>IReAxleMaxAvlblWhlDrvTqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Maximum  Available  Wheel Drive Torque Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PEU_10ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:后轴最大可用驱动扭矩有效性
接收方描述:后轴最大可用驱动扭矩有效性
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ReAxleMaxAvlblWhlDrvTqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlDrvTqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlDrvTqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c7daXOa505a3f19f25843c4b34c7d900">
              <SHORT-NAME>IReAxleMaxAvlblWhlRgtnTq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Maximum  Available  Wheel Regeneration Torque</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PEU_10ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:后轴最大可用回收扭矩
接收方描述:后轴最大可用回收扭矩
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ReAxleMaxAvlblWhlRgtnTq</SHORT-LABEL>
                  <VALUE>0x7FFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlRgtnTq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlRgtnTq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c7f6XOa505a3f19f25843c4b34c7f500">
              <SHORT-NAME>IReAxleMaxAvlblWhlRgtnTqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Maximum  Available  Wheel Regeneration Torque Valid</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PEU_10ms_Group25
功能安全:Y
信息安全:
有无服务标签:
发送方描述:后轴最大可用回收扭矩有效性
接收方描述:后轴最大可用回收扭矩有效性
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ReAxleMaxAvlblWhlRgtnTqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ReAxleMaxAvlblWhlRgtnTqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ReAxleMaxAvlblWhlRgtnTqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b0f3XOa505a3f19f25843c4b37b0f200">
              <SHORT-NAME>IRearFogLghtFltsts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Fog_Light_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后雾灯故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RearFogLghtFltsts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RearFogLghtFltsts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RearFogLghtFltsts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b10eXOa505a3f19f25843c4b37b10d00">
              <SHORT-NAME>IRearFogLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Fog_Light_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:后雾灯状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RearFogLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RearFogLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RearFogLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31b1fbXOa505a3f19f25843c4b31b1fa00">
              <SHORT-NAME>IResetCnt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reset Counter</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):Event
Signal Group:
功能安全:
信息安全:Y
有无服务标签:
发送方描述:构成SecOC同步报文
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):0.0
Num. Of Repetition:0.0
Signal Type:UNM
备注:网络安全</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>ResetCnt</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/ResetCnt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/ResetCnt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e3440XOa505a3f19f25843c4b2e343f00">
              <SHORT-NAME>IRevsLghtCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reverse_Light_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:倒车灯控制
接收方描述:倒车灯控制
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RevsLghtCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c125XOa505a3f19f25843c4b37c12400">
              <SHORT-NAME>IRevsLghtF_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reverse Light Failed_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光故障状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RevsLghtF_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtF_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b129XOa505a3f19f25843c4b37b12800">
              <SHORT-NAME>IRevsLghtFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reverse_Light_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:倒车灯故障状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RevsLghtFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c141XOa505a3f19f25843c4b37c14000">
              <SHORT-NAME>IRevsLghtOn_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reverse Light On_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RevsLghtOn_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtOn_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtOn_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37b144XOa505a3f19f25843c4b37b14300">
              <SHORT-NAME>IRevsLghtSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Reverse Light Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RZCU_50ms_Group37
功能安全:
信息安全:
有无服务标签:
发送方描述:倒车灯状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RevsLghtSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RevsLghtSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RevsLghtSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbe9f2XNa505a3f19f34f4acdbbe9e300">
              <SHORT-NAME>IRgnLvReqFICM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Regen Level Request Front Infotainment Control Module</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group19
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RgnLvReqFICM</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgnLvReqFICM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Na505a3f19f34f4acdbbea1bXNa505a3f19f34f4acdbbea0c00">
              <SHORT-NAME>IRgnLvReqFICMV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Regen Level Request Front Infotainment Control Module Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:ICBVC_100ms_Group19
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:PICU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RgnLvReqFICMV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgnLvReqFICMV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgnLvReqFICMV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366017XOa505a3f19f25843c4b36601600">
              <SHORT-NAME>IRgtvBrkFnFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Regenerative Brake Function Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:再生制动功能故障状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RgtvBrkFnFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgtvBrkFnFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366036XOa505a3f19f25843c4b36603500">
              <SHORT-NAME>IRgtvBrkFnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Regenerative Brake Function Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group07
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:再生制动功能状态
接收方描述:ZXDAD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:EPS,IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RgtvBrkFnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RgtvBrkFnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RgtvBrkFnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37f94eXOa505a3f19f25843c4b37f94d00">
              <SHORT-NAME>IRightEyeOccludeStatus_IMM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Right Eye Occlude Status_IMM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:IMM_50ms_Group02
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:右眼遮挡状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RightEyeOccludeStatus_IMM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RightEyeOccludeStatus_IMM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RightEyeOccludeStatus_IMM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375871XOa505a3f19f25843c4b37587000">
              <SHORT-NAME>IRmtDrvrTrgtEPSStrgWhlAng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Driver Target EPS Steering Wheel Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtDrvrTrgtEPSStrgWhlAng</SHORT-LABEL>
                  <VALUE>0x8000</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtDrvrTrgtEPSStrgWhlAng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtDrvrTrgtEPSStrgWhlAng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37588cXOa505a3f19f25843c4b37588b00">
              <SHORT-NAME>IRmtParkngAstAbotBtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Parking Assist Abort Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtParkngAstAbotBtnSts</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstAbotBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstAbotBtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3758a7XOa505a3f19f25843c4b3758a600">
              <SHORT-NAME>IRmtParkngAstBtnSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Parking Assist Button Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtParkngAstBtnSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstBtnSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstBtnSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3758c2XOa505a3f19f25843c4b3758c100">
              <SHORT-NAME>IRmtParkngAstDvcFlrRsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Parking Assist Device Failure Reason</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:IAM
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtParkngAstDvcFlrRsn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstDvcFlrRsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcFlrRsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3758ddXOa505a3f19f25843c4b3758dc00">
              <SHORT-NAME>IRmtParkngAstDvcSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Parking Assist Device Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtParkngAstDvcSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstDvcSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstDvcSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3758f8XOa505a3f19f25843c4b3758f700">
              <SHORT-NAME>IRmtParkngAstParkngOutDircnSeln</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Remote Parking Assist Parking Out Direction Selection</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IAM_20ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RmtParkngAstParkngOutDircnSeln</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RmtParkngAstParkngOutDircnSeln</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RmtParkngAstParkngOutDircnSeln</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e96c9XOa505a3f19f25843c4b2e96c800">
              <SHORT-NAME>IRoadCrvt</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Curvature</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:null
发送方描述:导航外发曲率
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadCrvt</SHORT-LABEL>
                  <VALUE>0x20000</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>18</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT32</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadCrvt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e96e4XOa505a3f19f25843c4b2e96e300">
              <SHORT-NAME>IRoadCrvtDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Curvature Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:导航外发曲率有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadCrvtDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadCrvtDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadCrvtDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346401XOa505a3f19f25843c4b34640000">
              <SHORT-NAME>IRoadHeightL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of road Feature L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadHeightL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadHeightL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadHeightL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34626bXOa505a3f19f25843c4b34626a00">
              <SHORT-NAME>IRoadHeightR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of road Feature R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadHeightR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadHeightR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadHeightR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31aef4XOa505a3f19f25843c4b31aef300">
              <SHORT-NAME>IRoadProfileShockConfidenceL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3464daXOa505a3f19f25843c4b3464d900">
              <SHORT-NAME>IRoadProfileShockConfidenceL1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_L_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceL1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3464bfXOa505a3f19f25843c4b3464be00">
              <SHORT-NAME>IRoadProfileShockConfidenceL2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_L_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceL2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3462f2XOa505a3f19f25843c4b3462f100">
              <SHORT-NAME>IRoadProfileShockConfidenceL3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_L_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceL3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceL3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31ae78XOa505a3f19f25843c4b31ae7700">
              <SHORT-NAME>IRoadProfileShockConfidenceR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346286XOa505a3f19f25843c4b34628500">
              <SHORT-NAME>IRoadProfileShockConfidenceR1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_R_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceR1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34652bXOa505a3f19f25843c4b34652a00">
              <SHORT-NAME>IRoadProfileShockConfidenceR2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_R_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceR2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346561XOa505a3f19f25843c4b34656000">
              <SHORT-NAME>IRoadProfileShockConfidenceR3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Confidence Of The Shock Detection_R_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockConfidenceR3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockConfidenceR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockConfidenceR3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31adfcXOa505a3f19f25843c4b31adfb00">
              <SHORT-NAME>IRoadProfileShockDetectedL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3463b0XOa505a3f19f25843c4b3463af00">
              <SHORT-NAME>IRoadProfileShockDetectedL1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_L_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedL1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346328XOa505a3f19f25843c4b34632700">
              <SHORT-NAME>IRoadProfileShockDetectedL2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_L_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedL2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34641cXOa505a3f19f25843c4b34641b00">
              <SHORT-NAME>IRoadProfileShockDetectedL3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_L_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedL3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedL3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31ae3aXOa505a3f19f25843c4b31ae3900">
              <SHORT-NAME>IRoadProfileShockDetectedR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34630dXOa505a3f19f25843c4b34630c00">
              <SHORT-NAME>IRoadProfileShockDetectedR1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_R_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedR1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3461ffXOa505a3f19f25843c4b3461fe00">
              <SHORT-NAME>IRoadProfileShockDetectedR2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_R_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedR2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3461aeXOa505a3f19f25843c4b3461ad00">
              <SHORT-NAME>IRoadProfileShockDetectedR3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An Indication That A Shock Feature Has Been Detected_R_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDetectedR3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDetectedR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDetectedR3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346235XOa505a3f19f25843c4b34623400">
              <SHORT-NAME>IRoadProfileShockDistL1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The First Shock Feature Along The Rolling Path L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistL1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3463e6XOa505a3f19f25843c4b3463e500">
              <SHORT-NAME>IRoadProfileShockDistL2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The Second Shock Feature Along The Rolling Path L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistL2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346177XOa505a3f19f25843c4b34617600">
              <SHORT-NAME>IRoadProfileShockDistL3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The Third Shock Feature Along The Rolling Path L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistL3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistL3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34637aXOa505a3f19f25843c4b34637900">
              <SHORT-NAME>IRoadProfileShockDistR1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The First Shock Feature Along The Rolling Path R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistR1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346193XOa505a3f19f25843c4b34619200">
              <SHORT-NAME>IRoadProfileShockDistR2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The Second Shock Feature Along The Rolling Path R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistR2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3463cbXOa505a3f19f25843c4b3463ca00">
              <SHORT-NAME>IRoadProfileShockDistR3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Distance To The Leading Edge Of The Third Shock Feature Along The Rolling Path R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockDistR3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockDistR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockDistR3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31adddXOa505a3f19f25843c4b31addc00">
              <SHORT-NAME>IRoadProfileShockHeightL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346395XOa505a3f19f25843c4b34639400">
              <SHORT-NAME>IRoadProfileShockHeightL1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_L_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightL1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3462bcXOa505a3f19f25843c4b3462bb00">
              <SHORT-NAME>IRoadProfileShockHeightL2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_L_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightL2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346546XOa505a3f19f25843c4b34654500">
              <SHORT-NAME>IRoadProfileShockHeightL3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_L_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightL3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightL3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightL3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31ae59XOa505a3f19f25843c4b31ae5800">
              <SHORT-NAME>IRoadProfileShockHeightR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346250XOa505a3f19f25843c4b34624f00">
              <SHORT-NAME>IRoadProfileShockHeightR1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_R_1</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightR1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346510XOa505a3f19f25843c4b34650f00">
              <SHORT-NAME>IRoadProfileShockHeightR2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_R_2</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightR2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3462d7XOa505a3f19f25843c4b3462d600">
              <SHORT-NAME>IRoadProfileShockHeightR3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">The Height Of The Shock Feature_R_3</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:SNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockHeightR3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/SINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockHeightR3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockHeightR3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31aeb6XOa505a3f19f25843c4b31aeb500">
              <SHORT-NAME>IRoadProfileShockLevelL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Profile Shock Level L</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockLevelL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockLevelL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockLevelL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31ae97XOa505a3f19f25843c4b31ae9600">
              <SHORT-NAME>IRoadProfileShockLevelR</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Profile Shock Level R</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadProfileShockLevelR</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadProfileShockLevelR</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadProfileShockLevelR</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e96ffXOa505a3f19f25843c4b2e96fe00">
              <SHORT-NAME>IRoadSlope</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Slope</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:null
发送方描述:导航外发坡度值
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadSlope</SHORT-LABEL>
                  <VALUE>0x800</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>12</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadSlope</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlope</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e971aXOa505a3f19f25843c4b2e971900">
              <SHORT-NAME>IRoadSlopeDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Road Slope Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:导航外发坡度值有效性
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoadSlopeDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoadSlopeDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoadSlopeDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ebfefXOa505a3f19f25843c4b2ebfee00">
              <SHORT-NAME>IRolloff2Min_flg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rolloff2Min_flg</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>Rolloff2Min_flg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/Rolloff2Min_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/Rolloff2Min_flg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec125XOa505a3f19f25843c4b2ec12400">
              <SHORT-NAME>IRolloffHld_flg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RolloffHld_flg</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RolloffHld_flg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RolloffHld_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RolloffHld_flg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34c437XOa505a3f19f25843c4b34c43600">
              <SHORT-NAME>IRoughRoaddetection</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An_indication_that_a_rough Road_feature_has_been_detected</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:产品定义的CDC新增APC功能需求：破碎路检测
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoughRoaddetection</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoughRoaddetection</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetection</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9735XOa505a3f19f25843c4b2e973400">
              <SHORT-NAME>IRoughRoaddetectionDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">An_indication_that_a_rough Road_feature_has_been_detected_distence</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:产品定义的CDC新增APC功能需求：破碎路检测距离
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:CDC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RoughRoaddetectionDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>10</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RoughRoaddetectionDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RoughRoaddetectionDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36802dXOa505a3f19f25843c4b36802c00">
              <SHORT-NAME>IRrAxleActuWhlToq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Actual Wheel Torque</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PICU_10ms_Group03
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrAxleActuWhlToq</SHORT-LABEL>
                  <VALUE>0x7530</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrAxleActuWhlToq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrAxleActuWhlToq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36804cXOa505a3f19f25843c4b36804b00">
              <SHORT-NAME>IRrAxleActuWhlToqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Axle Actual Wheel Torque Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:PICU_10ms_Group03
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrAxleActuWhlToqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrAxleActuWhlToqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrAxleActuWhlToqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37dfa0XOa505a3f19f25843c4b37df9f00">
              <SHORT-NAME>IRrBmpAntFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Bumper Antenna Fault Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:LHZCU
接收方描述:RHZCU
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:无钥匙进入与启动</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrBmpAntFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrBmpAntFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrBmpAntFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b791XOa505a3f19f25843c4b34b79000">
              <SHORT-NAME>IRrCrnRdrCalSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Corner Radar Calibration Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:RHRDA_50ms_Group04
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后角雷达标定提示
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrCrnRdrCalSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrCrnRdrCalSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrCrnRdrCalSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c15dXOa505a3f19f25843c4b37c15c00">
              <SHORT-NAME>IRrFogLghtF_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Fog Light Failed_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光故障状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrFogLghtF_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLghtF_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLghtF_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37c179XOa505a3f19f25843c4b37c17800">
              <SHORT-NAME>IRrFogLghtOn_TDM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Fog Light On_TDM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):200.0
Signal Group:TDM_200ms_Group01
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:后车灯光开启状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrFogLghtOn_TDM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLghtOn_TDM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLghtOn_TDM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b378337XOa505a3f19f25843c4b37833600">
              <SHORT-NAME>IRrFogLightOnReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Fog Light On Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):10.0
Signal Group:LHZCU_10ms_Group32
功能安全:
信息安全:
有无服务标签:
发送方描述:后雾灯满足请求点亮
接收方描述:ICB路由中转
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:外灯</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrFogLightOnReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrFogLightOnReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrFogLightOnReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3240c9XOa505a3f19f25843c4b3240c800">
              <SHORT-NAME>IRrMidLObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Middle_Left_Obstacle_Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrMidLObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrMidLObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrMidLObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b324753XOa505a3f19f25843c4b32475200">
              <SHORT-NAME>IRrMidRObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Middle Right Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrMidRObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrMidRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrMidRObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b323ccaXOa505a3f19f25843c4b323cc900">
              <SHORT-NAME>IRrObsDist</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Right Obstacle Distance</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrObsDist</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrObsDist</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrObsDist</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b32446bXOa505a3f19f25843c4b32446a00">
              <SHORT-NAME>IRrPDCAudWrnng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Body Control Module Rear Park Distance Control Audible Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrPDCAudWrnng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrPDCAudWrnng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrPDCAudWrnng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34966eXOa505a3f19f25843c4b34966d00">
              <SHORT-NAME>IRrPDCPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">RrPDC Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:ZXD播报负载配电通断状态
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrPDCPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrPDCPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrPDCPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b374f6aXOa505a3f19f25843c4b374f6900">
              <SHORT-NAME>IRrSrvcPosReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Service Position Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后雨刮服务请求
接收方描述:RZCU执行后雨刮
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:雨刮洗涤</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrSrvcPosReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSrvcPosReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrSrvcPosReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ac01XOa505a3f19f25843c4b37ac0000">
              <SHORT-NAME>IRrSsdAppCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Sunshade_Application_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:发送后遮阳帘应用控制请求
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:天窗遮阳帘</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrSsdAppCtrl</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSsdAppCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrSsdAppCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ac1cXOa505a3f19f25843c4b37ac1b00">
              <SHORT-NAME>IRrSsdPosCtrl</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Sunshade_Position_Control</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:发送后遮阳帘百分比位置请求（有效位置为0-100）
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:天窗遮阳帘</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrSsdPosCtrl</SHORT-LABEL>
                  <VALUE>0xFF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrSsdPosCtrl</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrSsdPosCtrl</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34668aXOa505a3f19f25843c4b34668900">
              <SHORT-NAME>IRrTireStdPrs</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear_Tire_Standard_Pressure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后部轮胎标准压力
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrTireStdPrs</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrTireStdPrs</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrTireStdPrs</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b374cc7XOa505a3f19f25843c4b374cc600">
              <SHORT-NAME>IRrWiperFnEnb</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Wiper Function Enable</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后雨刮使能
接收方描述:RZCU执行后雨刮
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:雨刮洗涤</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrWiperFnEnb</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrWiperFnEnb</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrWiperFnEnb</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375198XOa505a3f19f25843c4b37519700">
              <SHORT-NAME>IRrWiperReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Rear Wiper Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:后雨刮请求
接收方描述:RZCU执行后雨刮
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:雨刮洗涤</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RrWiperReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RrWiperReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RrWiperReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8464XOa505a3f19f25843c4b2e846300">
              <SHORT-NAME>IRstrFctryDeftsReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Restore Factory Defaults Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):25.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:恢复出厂设置信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>RstrFctryDeftsReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/RstrFctryDeftsReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/RstrFctryDeftsReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b374696XOa505a3f19f25843c4b37469500">
              <SHORT-NAME>ISACPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SACPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SACPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SACPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376632XOa505a3f19f25843c4b37663100">
              <SHORT-NAME>ISAC_ExtdAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_ExtdAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_ExtdAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_ExtdAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341ba5XOa505a3f19f25843c4b341ba400">
              <SHORT-NAME>ISAC_NKI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC PTCANFD Network Keep Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NKI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NKI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NKI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341885XOa505a3f19f25843c4b34188400">
              <SHORT-NAME>ISAC_NM_BSMtoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM BSMtoRMS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_BSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_BSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_BSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3419f6XOa505a3f19f25843c4b3419f500">
              <SHORT-NAME>ISAC_NM_NOSSta_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM NOSSta PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_NOSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_NOSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_NOSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341cd4XOa505a3f19f25843c4b341cd300">
              <SHORT-NAME>ISAC_NM_NOStoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM NOStoRMS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_NOStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_NOStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_NOStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341c6cXOa505a3f19f25843c4b341c6b00">
              <SHORT-NAME>ISAC_NM_PBSMtoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM PBSMtoRMS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_PBSMtoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_PBSMtoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_PBSMtoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3419dbXOa505a3f19f25843c4b3419da00">
              <SHORT-NAME>ISAC_NM_RMSSta_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM RMSSta PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_RMSSta_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RMSSta_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_RMSSta_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341992XOa505a3f19f25843c4b34199100">
              <SHORT-NAME>ISAC_NM_RMStoNOS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM RMStoNOS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_RMStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RMStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_RMStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341b3dXOa505a3f19f25843c4b341b3c00">
              <SHORT-NAME>ISAC_NM_RSStoNOS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM RSStoNOS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_RSStoNOS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RSStoNOS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_RSStoNOS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341c87XOa505a3f19f25843c4b341c8600">
              <SHORT-NAME>ISAC_NM_RSStoRMS_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC NM RSStoRMS PTCANFD</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NM_RSStoRMS_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NM_RSStoRMS_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NM_RSStoRMS_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341bd6XOa505a3f19f25843c4b341bd500">
              <SHORT-NAME>ISAC_NOI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC PTCANFD Network Operation Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NOI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NOI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NOI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b341a5aXOa505a3f19f25843c4b341a5900">
              <SHORT-NAME>ISAC_NWI_PTCANFD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC PTCANFD Network Wakeup Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):NA
Signal Group:
功能安全:null
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):NA
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:网络管理</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_NWI_PTCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_NWI_PTCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_NWI_PTCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3802b1XOa505a3f19f25843c4b3802b000">
              <SHORT-NAME>ISAC_PTAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SAC Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SAC_PTAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SAC_PTAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SAC_PTAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376a58XOa505a3f19f25843c4b376a5700">
              <SHORT-NAME>ISASAvlbly</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SASAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SASAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SASAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3668c8XOa505a3f19f25843c4b3668c700">
              <SHORT-NAME>ISCSAPAAcclA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Advanced Park Assist Acceleration Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSAPAAcclA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAPAAcclA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3668e7XOa505a3f19f25843c4b3668e600">
              <SHORT-NAME>ISCSAPAAcclAV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Advanced Park Assist Acceleration Active Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSAPAAcclAV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAPAAcclAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAPAAcclAV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366906XOa505a3f19f25843c4b36690500">
              <SHORT-NAME>ISCSAutodDrvngSysSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Automated Driving System Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSAutodDrvngSysSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAutodDrvngSysSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366925XOa505a3f19f25843c4b36692400">
              <SHORT-NAME>ISCSAutodDrvngSysStsV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Automated Driving System Status Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:APA功能使用
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSAutodDrvngSysStsV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSAutodDrvngSysStsV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSAutodDrvngSysStsV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3766efXOa505a3f19f25843c4b3766ee00">
              <SHORT-NAME>ISCSMdSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSMdSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSMdSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSMdSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366944XOa505a3f19f25843c4b36694300">
              <SHORT-NAME>ISCSVehHoldA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Vehicle Hold Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:IBS保压状态（APA）
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSVehHoldA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSVehHoldA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366963XOa505a3f19f25843c4b36696200">
              <SHORT-NAME>ISCSVehHoldAV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Stability Control System Vehicle Hold A Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:IBS_20ms_Group13
功能安全:ASIL A
信息安全:
有无服务标签:
发送方描述:IBS保压状态（APA）
接收方描述:FVCM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:IBS,AC</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCSVehHoldAV</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCSVehHoldAV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCSVehHoldAV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b347d58XOa505a3f19f25843c4b347d5700">
              <SHORT-NAME>ISCUAPAUnderCtrlA_TCM</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUAPAUnderCtrlA_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUAPAUnderCtrlA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUAPAUnderCtrlA_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ff6aXOa505a3f19f25843c4b37ff6900">
              <SHORT-NAME>ISCUAPAUnderCtrlActv</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Auto Parking Assist Under Control Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:SCU智驾模式状态信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUAPAUnderCtrlActv</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUAPAUnderCtrlActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUAPAUnderCtrlActv</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376e2cXOa505a3f19f25843c4b376e2b00">
              <SHORT-NAME>ISCUActrMvmntSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUActrMvmntSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUActrMvmntSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUActrMvmntSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ff86XOa505a3f19f25843c4b37ff8500">
              <SHORT-NAME>ISCUDrvMd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Drive Mode</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:N挡推车模式信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUDrvMd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvMd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvMd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376e44XOa505a3f19f25843c4b376e4300">
              <SHORT-NAME>ISCUDrvnIntrvnPos</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUDrvnIntrvnPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvnIntrvnPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvnIntrvnPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b347d6fXOa505a3f19f25843c4b347d6e00">
              <SHORT-NAME>ISCUDrvrIntrvnA_TCM</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Driver Intervention Active_TCM</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:TCM_020ms_PDU18
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUDrvrIntrvnA_TCM</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvrIntrvnA_TCM</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvrIntrvnA_TCM</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ffa2XOa505a3f19f25843c4b37ffa100">
              <SHORT-NAME>ISCUDrvrIntrvnActv</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Driver Intervention Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:驾驶员干预提示信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUDrvrIntrvnActv</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUDrvrIntrvnActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUDrvrIntrvnActv</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376e5cXOa505a3f19f25843c4b376e5b00">
              <SHORT-NAME>ISCUExtdShifterActrPos</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUExtdShifterActrPos</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUExtdShifterActrPos</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShifterActrPos</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ffbeXOa505a3f19f25843c4b37ffbd00">
              <SHORT-NAME>ISCUExtdShiftrFlr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Extended Shifter Failure</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:SCU检测故障信息
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUExtdShiftrFlr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUExtdShiftrFlr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUExtdShiftrFlr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37ffdaXOa505a3f19f25843c4b37ffd900">
              <SHORT-NAME>ISCUFltLvlWarn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Fault Level Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:SCU故障提醒信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUFltLvlWarn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUFltLvlWarn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUFltLvlWarn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376e74XOa505a3f19f25843c4b376e7300">
              <SHORT-NAME>ISCUParkActrSts</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUParkActrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkActrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkActrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37fff6XOa505a3f19f25843c4b37fff500">
              <SHORT-NAME>ISCUParkLckReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Park Lock Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:SCU档位请求,SCU请求EPB拉起,EPB关联请求信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUParkLckReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380012XOa505a3f19f25843c4b38001100">
              <SHORT-NAME>ISCUParkLckReqEPMCU</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Park Lock Request Electrical Parking Motor Control Unit</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:SCU对EPMCU请求,EPMCU关联请求信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUParkLckReqEPMCU</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqEPMCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqEPMCU</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b38002eXOa505a3f19f25843c4b38002d00">
              <SHORT-NAME>ISCUParkLckReqV</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Park Lock Request Validity</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:valid,SCU请求EPB拉起有效值,EPB关联请求有效性信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUParkLckReqV</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqV</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqV</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b38004aXOa505a3f19f25843c4b38004900">
              <SHORT-NAME>ISCUParkLckReqVEPMCU</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Park Lock Request Validity Electrical Parking Motor Control Unit</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:valid,EPMCU关联请求有效性信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUParkLckReqVEPMCU</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUParkLckReqVEPMCU</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUParkLckReqVEPMCU</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376e8cXOa505a3f19f25843c4b376e8b00">
              <SHORT-NAME>ISCUShftLvrPosIncnstntFlag</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShftLvrPosIncnstntFlag</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShftLvrPosIncnstntFlag</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosIncnstntFlag</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376ea4XOa505a3f19f25843c4b376ea300">
              <SHORT-NAME>ISCUShftLvrPosTrgt</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShftLvrPosTrgt</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShftLvrPosTrgt</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShftLvrPosTrgt</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380066XOa505a3f19f25843c4b38006500">
              <SHORT-NAME>ISCUShiftrLvrPosn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Shifter Lever Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL A,ASIL B
信息安全:
有无服务标签:
发送方描述:SCU档位,SCU换挡杆位置有效值,驾驶员意图挡位信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShiftrLvrPosn</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrPosn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380082XOa505a3f19f25843c4b38008100">
              <SHORT-NAME>ISCUShiftrLvrPosnLtchActv</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Shifter Lever Position Latch Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:驾驶员意图挡位Latch状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShiftrLvrPosnLtchActv</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrPosnLtchActv</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrPosnLtchActv</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b38009eXOa505a3f19f25843c4b38009d00">
              <SHORT-NAME>ISCUShiftrLvrRawPosn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Shifter Lever Raw Position</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASILB,ASIL B
信息安全:
有无服务标签:
发送方描述:换挡杆实际位置信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:VS,IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShiftrLvrRawPosn</SHORT-LABEL>
                  <VALUE>0x2</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrLvrRawPosn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrLvrRawPosn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3800baXOa505a3f19f25843c4b3800b900">
              <SHORT-NAME>ISCUShiftrOpngRmndr</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Shifter Operating Reminder</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:挡位切换提示信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS，SCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShiftrOpngRmndr</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrOpngRmndr</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrOpngRmndr</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3800d6XOa505a3f19f25843c4b3800d500">
              <SHORT-NAME>ISCUShiftrPosnInvsn</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Shifter Control Unit Shifter Position Inversion</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group01
功能安全:ASIL B
信息安全:
有无服务标签:
发送方描述:驾驶员意图挡位信号取反
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:IBS</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUShiftrPosnInvsn</SHORT-LABEL>
                  <VALUE>0xF</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUShiftrPosnInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUShiftrPosnInvsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376ebcXOa505a3f19f25843c4b376ebb00">
              <SHORT-NAME>ISCUTapUpDwnSwSta</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUTapUpDwnSwSta</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUTapUpDwnSwSta</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwSta</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b376ed4XOa505a3f19f25843c4b376ed300">
              <SHORT-NAME>ISCUTapUpDwnSwStaInvsn</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:LHZCU_10ms_Group32
功能安全:Y
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SCUTapUpDwnSwStaInvsn</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SCUTapUpDwnSwStaInvsn</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SCUTapUpDwnSwStaInvsn</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b36b9afXOa505a3f19f25843c4b36b9ae00">
              <SHORT-NAME>ISDMAvlbly</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM CHCANFD Availability</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDMAvlbly</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDMAvlbly</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDMAvlbly</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e84c0XOa505a3f19f25843c4b2e84bf00">
              <SHORT-NAME>ISDMPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDMPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDMPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDMPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366fc9XOa505a3f19f25843c4b366fc800">
              <SHORT-NAME>ISDM_20ms_Group01_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group01_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b366fe9XOa505a3f19f25843c4b366fe800">
              <SHORT-NAME>ISDM_20ms_Group01_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group01_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group01
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f29f2XOa505a3f19f25843c4b2f29f100">
              <SHORT-NAME>ISDM_20ms_Group01_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_Reserved1</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f2a0aXOa505a3f19f25843c4b2f2a0900">
              <SHORT-NAME>ISDM_20ms_Group01_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_Reserved2</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f2a21XOa505a3f19f25843c4b2f2a2000">
              <SHORT-NAME>ISDM_20ms_Group01_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_Reserved3</SHORT-LABEL>
                  <VALUE>0x3f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f2a38XOa505a3f19f25843c4b2f2a3700">
              <SHORT-NAME>ISDM_20ms_Group01_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group01_Reserved4</SHORT-LABEL>
                  <VALUE>0x3f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group01_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group01_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3670c5XOa505a3f19f25843c4b3670c400">
              <SHORT-NAME>ISDM_20ms_Group02_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group02_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3670e4XOa505a3f19f25843c4b3670e300">
              <SHORT-NAME>ISDM_20ms_Group02_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group02_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group02
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e90130a5aXN200000119f58e5e90130a5400">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved16</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved16</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved16</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e90130d2fXN200000119f58e5e90130d2900">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved31</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved31</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved31</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved31</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e90131000XN200000119f58e5e90130ffa00">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved37</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved37</SHORT-LABEL>
                  <VALUE>0x3f</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>6</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved37</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved37</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e901312caXN200000119f58e5e901312c400">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved47</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved47</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved47</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved47</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e9013158aXN200000119f58e5e9013158400">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved51</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved51</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved51</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved51</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e90131b1fXN200000119f58e5e90131b1900">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved57</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved57</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved57</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved57</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="N200000119f58e5e9013185bXN200000119f58e5e9013185500">
              <SHORT-NAME>ISDM_20ms_Group02_Reserved63</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group02_Reserved63</SHORT-LABEL>
                  <VALUE>0x7</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group02_Reserved63</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group02_Reserved63</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3671c8XOa505a3f19f25843c4b3671c700">
              <SHORT-NAME>ISDM_20ms_Group03_CRC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group03_CRC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_CRC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_CRC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_CRC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3671e7XOa505a3f19f25843c4b3671e600">
              <SHORT-NAME>ISDM_20ms_Group03_RC</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDM_20ms_Group03_RC</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:SDM_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_RC</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_RC</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_RC</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f297fXOa505a3f19f25843c4b2f297e00">
              <SHORT-NAME>ISDM_20ms_Group03_Reserved1</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_Reserved1</SHORT-LABEL>
                  <VALUE>0xf</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f2997XOa505a3f19f25843c4b2f299600">
              <SHORT-NAME>ISDM_20ms_Group03_Reserved2</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_Reserved2</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f29aeXOa505a3f19f25843c4b2f29ad00">
              <SHORT-NAME>ISDM_20ms_Group03_Reserved3</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_Reserved3</SHORT-LABEL>
                  <VALUE>0x3</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2f29c5XOa505a3f19f25843c4b2f29c400">
              <SHORT-NAME>ISDM_20ms_Group03_Reserved4</SHORT-NAME>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_20ms_Group03_Reserved4</SHORT-LABEL>
                  <VALUE>0xff</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_20ms_Group03_Reserved4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_20ms_Group03_Reserved4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372d99XOa505a3f19f25843c4b372d9800">
              <SHORT-NAME>ISDM_NKI_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NKI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NKI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NKI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b372910XOa505a3f19f25843c4b37290f00">
              <SHORT-NAME>ISDM_NM_BSMtoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_BSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_BSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_BSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3733f1XOa505a3f19f25843c4b3733f000">
              <SHORT-NAME>ISDM_NM_NOSSta_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_NOSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_NOSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_NOSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373ae7XOa505a3f19f25843c4b373ae600">
              <SHORT-NAME>ISDM_NM_NOStoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_NOStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_NOStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_NOStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373700XOa505a3f19f25843c4b3736ff00">
              <SHORT-NAME>ISDM_NM_PBSMtoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_PBSMtoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_PBSMtoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_PBSMtoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373ba4XOa505a3f19f25843c4b373ba300">
              <SHORT-NAME>ISDM_NM_RMSSta_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_RMSSta_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RMSSta_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_RMSSta_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b37385fXOa505a3f19f25843c4b37385e00">
              <SHORT-NAME>ISDM_NM_RMStoNOS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_RMStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RMStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_RMStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373c2bXOa505a3f19f25843c4b373c2a00">
              <SHORT-NAME>ISDM_NM_RSStoNOS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_RSStoNOS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RSStoNOS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_RSStoNOS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373901XOa505a3f19f25843c4b37390000">
              <SHORT-NAME>ISDM_NM_RSStoRMS_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):0.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NM_RSStoRMS_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NM_RSStoRMS_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NM_RSStoRMS_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373385XOa505a3f19f25843c4b37338400">
              <SHORT-NAME>ISDM_NOI_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NOI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>16</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NOI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NOI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b373207XOa505a3f19f25843c4b37320600">
              <SHORT-NAME>ISDM_NWI_SFCANFD</SHORT-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDM_NWI_SFCANFD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>8</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDM_NWI_SFCANFD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDM_NWI_SFCANFD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375a75XOa505a3f19f25843c4b375a7400">
              <SHORT-NAME>ISDWLSFObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDW Left Side Front Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group14
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDWLSFObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWLSFObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSFObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375a90XOa505a3f19f25843c4b375a8f00">
              <SHORT-NAME>ISDWLSRObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDW Left Side Rear Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group14
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDWLSRObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWLSRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWLSRObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375aabXOa505a3f19f25843c4b375aaa00">
              <SHORT-NAME>ISDWRSFObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDW Right Side Front Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group14
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDWRSFObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWRSFObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSFObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b375ac6XOa505a3f19f25843c4b375ac500">
              <SHORT-NAME>ISDWRSRObsRng</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SDW Right Side Rear Obstacle Range</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:IPD_50ms_Group14
功能安全:
信息安全:
有无服务标签:null
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SDWRSRObsRng</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SDWRSRObsRng</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SDWRSRObsRng</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bed9XOa505a3f19f25843c4b34bed800">
              <SHORT-NAME>ISLIFAudWrnng_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Audible Warning</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SLIF超速报警音提示激活
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFAudWrnng_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFAudWrnng_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFAudWrnng_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2eab59XOa505a3f19f25843c4b2eab5800">
              <SHORT-NAME>ISLIFSts_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100ms
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS系统状态反馈
接收方描述:ZXD
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:智驾</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFSts_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFSts_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFSts_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b380127XOa505a3f19f25843c4b38012600">
              <SHORT-NAME>ISLIFSysFltSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed_Limit_Information_Function_System_Fault_Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SAS故障状态信号
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFSysFltSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>3</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFSysFltSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFSysFltSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8d64XOa505a3f19f25843c4b2e8d6300">
              <SHORT-NAME>ISLIFUpdtIndReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Update Indication Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:智能超速报警限速更新提示音开关
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):
Num. Of Repetition:
Signal Type:ENM
备注:EV 智能限速</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFUpdtIndReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtIndReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtIndReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bef5XOa505a3f19f25843c4b34bef400">
              <SHORT-NAME>ISLIFUpdtIndResp_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Update Indication Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SLIF限速变化声音提示开关反馈
接收方描述:
Max. acceptable latency(ms):
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFUpdtIndResp_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtIndResp_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtIndResp_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34bf11XOa505a3f19f25843c4b34bf1000">
              <SHORT-NAME>ISLIFUpdtInd_IPD</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Update Indication</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):TBD
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:SLIF限速更新提示状态
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):TBD
Num. Of Repetition:TBD
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFUpdtInd_IPD</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFUpdtInd_IPD</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFUpdtInd_IPD</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3499caXOa505a3f19f25843c4b3499c900">
              <SHORT-NAME>ISLIFWrnngMdReq</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Warning Mode Request</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:SLIF限速告警开关请求
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFWrnngMdReq</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFWrnngMdReq</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFWrnngMdReq</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b346343XOa505a3f19f25843c4b34634200">
              <SHORT-NAME>ISLIFWrnngMdResp</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Speed Limit Information Function Warning Mode Response</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:null
信息安全:null
有无服务标签:null
发送方描述:SLIF限速告警开关反馈
接收方描述:null
Max. acceptable latency(ms):null
Repetition Period(ms):null
Num. Of Repetition:null
Signal Type:ENM
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SLIFWrnngMdResp</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>2</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SLIFWrnngMdResp</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SLIFWrnngMdResp</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec372XOa505a3f19f25843c4b2ec37100">
              <SHORT-NAME>ISOCLowPwrDwn_flg</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SOCLowPwrDwn_flg</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:BLN
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SOCLowPwrDwn_flg</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCLowPwrDwn_flg</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCLowPwrDwn_flg</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec562XOa505a3f19f25843c4b2ec56100">
              <SHORT-NAME>ISOCLvl_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SOCLvl_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SOCLvl_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCLvl_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCLvl_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2ec2d7XOa505a3f19f25843c4b2ec2d600">
              <SHORT-NAME>ISOCMd_enum</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">SOCMd_enum</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:开发帧信号，EP之后删除
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):
Num. Of Repetition:
Signal Type:UNM
备注:EV RZCU</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SOCMd_enum</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>4</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SOCMd_enum</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SOCMd_enum</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b34b6a5XOa505a3f19f25843c4b34b6a400">
              <SHORT-NAME>ISSBTrigd</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Start Stop Button Triggered</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):20.0
Signal Group:LHZCU_20ms_Group03
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:BKBCANFD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SSBTrigd</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SSBTrigd</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SSBTrigd</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e91c9XOa505a3f19f25843c4b2e91c800">
              <SHORT-NAME>ISWSCnfmSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Confirm Switch Active_l</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PICU, EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSCnfmSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSCnfmSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9750XOa505a3f19f25843c4b2e974f00">
              <SHORT-NAME>ISWSCnfmSwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Confirm Switch Stuck Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:ASIL C
信息安全:
有无服务标签:
发送方描述:set按键卡滞信号
接收方描述:PICM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:限速辅助，转发LIN信号</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSCnfmSwStuckL</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSCnfmSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSCnfmSwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e976bXOa505a3f19f25843c4b2e976a00">
              <SHORT-NAME>ISWSLFnChngSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Left Function Change Switch Active</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:ASIL C
信息安全:
有无服务标签:
发送方描述:限速按键
接收方描述:PICM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:限速辅助，转发LIN信号</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSLFnChngSwA</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSLFnChngSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSLFnChngSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9786XOa505a3f19f25843c4b2e978500">
              <SHORT-NAME>ISWSPB1SwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Push Button 1 Switch Stuck Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:ASIL C
信息安全:
有无服务标签:
发送方描述:Pilot按键卡滞信号
接收方描述:PICM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:限速辅助，转发LIN信号</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSPB1SwStuckL</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB1SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB1SwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e97a1XOa505a3f19f25843c4b2e97a000">
              <SHORT-NAME>ISWSPB2SwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Push Button 2 Switch Stuck Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:ASIL C
信息安全:
有无服务标签:
发送方描述:限速按键卡滞信号
接收方描述:PICM
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:限速辅助，转发LIN信号</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSPB2SwStuckL</SHORT-LABEL>
                  <VALUE>0x1</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB2SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB2SwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e97bcXOa505a3f19f25843c4b2e97bb00">
              <SHORT-NAME>ISWSPB3SwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Push Button 3 Switch Stuck
      Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:按键卡滞信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSPB3SwStuckL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPB3SwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPB3SwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e8599XOa505a3f19f25843c4b2e859800">
              <SHORT-NAME>ISWSPwrSts</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">LHSWS Power Status</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):100.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:ENM
备注:Efuse</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSPwrSts</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSPwrSts</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSPwrSts</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e91e8XOa505a3f19f25843c4b2e91e700">
              <SHORT-NAME>ISWSSelDwnSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Down Switch Active_l</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PICU, EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelDwnSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelDwnSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelDwnSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9207XOa505a3f19f25843c4b2e920600">
              <SHORT-NAME>ISWSSelLSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Left Switch Active_l</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PICU, EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelLSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelLSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e97d7XOa505a3f19f25843c4b2e97d600">
              <SHORT-NAME>ISWSSelLSwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Left Switch Stuck
      Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:按键卡滞信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelLSwStuckL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelLSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelLSwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9226XOa505a3f19f25843c4b2e922500">
              <SHORT-NAME>ISWSSelRSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Right Switch Active_l</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PICU, EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelRSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelRSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e97f2XOa505a3f19f25843c4b2e97f100">
              <SHORT-NAME>ISWSSelRSwStuckL</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Right Switch Stuck
      Left</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group256
功能安全:
信息安全:
有无服务标签:
发送方描述:按键卡滞信号
接收方描述:
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelRSwStuckL</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelRSwStuckL</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelRSwStuckL</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b2e9245XOa505a3f19f25843c4b2e924400">
              <SHORT-NAME>ISWSSelUpSwA</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Steering Wheel Switch Select Up Switch Active_l</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):50.0
Signal Group:ICBVC_50ms_Group11
功能安全:
信息安全:
有无服务标签:
发送方描述:
接收方描述:PICU, EPS
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:BLN
备注:HMI</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SWSSelUpSwA</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>1</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/BOOLEAN</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SWSSelUpSwA</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SWSSelUpSwA</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318bf0XOa505a3f19f25843c4b318bef00">
              <SHORT-NAME>ISatAz1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite1 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角1
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318547XOa505a3f19f25843c4b31854600">
              <SHORT-NAME>ISatAz10</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite10 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角10
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz10</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz10</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318718XOa505a3f19f25843c4b31871700">
              <SHORT-NAME>ISatAz11</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite11 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角11
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz11</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz11</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318965XOa505a3f19f25843c4b31896400">
              <SHORT-NAME>ISatAz12</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite12 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角12
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz12</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz12</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3180adXOa505a3f19f25843c4b3180ac00">
              <SHORT-NAME>ISatAz13</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite13 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角13
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz13</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz13</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318bd1XOa505a3f19f25843c4b318bd000">
              <SHORT-NAME>ISatAz14</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite14 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角14
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz14</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz14</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318b93XOa505a3f19f25843c4b318b9200">
              <SHORT-NAME>ISatAz15</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite15 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角15
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz15</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3188abXOa505a3f19f25843c4b3188aa00">
              <SHORT-NAME>ISatAz16</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite16 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角16
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz16</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz16</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3180ebXOa505a3f19f25843c4b3180ea00">
              <SHORT-NAME>ISatAz17</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite17 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角17
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz17</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz17</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318ad9XOa505a3f19f25843c4b318ad800">
              <SHORT-NAME>ISatAz18</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite18 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角18
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz18</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz18</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318b17XOa505a3f19f25843c4b318b1600">
              <SHORT-NAME>ISatAz19</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite19 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角19
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz19</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz19</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3186daXOa505a3f19f25843c4b3186d900">
              <SHORT-NAME>ISatAz2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite2 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角2
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3182bcXOa505a3f19f25843c4b3182bb00">
              <SHORT-NAME>ISatAz20</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite20 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角20
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz20</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz20</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318a00XOa505a3f19f25843c4b3189ff00">
              <SHORT-NAME>ISatAz3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite3 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角3
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318012XOa505a3f19f25843c4b31801100">
              <SHORT-NAME>ISatAz4</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite4 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角4
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz4</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31867dXOa505a3f19f25843c4b31867c00">
              <SHORT-NAME>ISatAz5</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite5 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角5
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz5</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31806fXOa505a3f19f25843c4b31806e00">
              <SHORT-NAME>ISatAz6</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite6 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角6
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz6</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31863fXOa505a3f19f25843c4b31863e00">
              <SHORT-NAME>ISatAz7</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite7 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角7
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz7</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318af8XOa505a3f19f25843c4b318af700">
              <SHORT-NAME>ISatAz8</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite8 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角8
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz8</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz8</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317ff3XOa505a3f19f25843c4b317ff200">
              <SHORT-NAME>ISatAz9</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite9 Azimuth Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星方位角9
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatAz9</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>9</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT16</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatAz9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatAz9</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317fb5XOa505a3f19f25843c4b317fb400">
              <SHORT-NAME>ISatCNO1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite1 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比1
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3180ccXOa505a3f19f25843c4b3180cb00">
              <SHORT-NAME>ISatCNO10</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite10 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比10
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO10</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO10</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318a9bXOa505a3f19f25843c4b318a9a00">
              <SHORT-NAME>ISatCNO11</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite11 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比11
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO11</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO11</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318376XOa505a3f19f25843c4b31837500">
              <SHORT-NAME>ISatCNO12</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite12 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比12
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO12</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO12</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317f58XOa505a3f19f25843c4b317f5700">
              <SHORT-NAME>ISatCNO13</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite13 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比13
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO13</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO13</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31884eXOa505a3f19f25843c4b31884d00">
              <SHORT-NAME>ISatCNO14</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite14 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比14
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO14</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO14</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318c0fXOa505a3f19f25843c4b318c0e00">
              <SHORT-NAME>ISatCNO15</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite15 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比15
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO15</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318b36XOa505a3f19f25843c4b318b3500">
              <SHORT-NAME>ISatCNO16</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite16 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比16
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO16</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO16</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318357XOa505a3f19f25843c4b31835600">
              <SHORT-NAME>ISatCNO17</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite17 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比17
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO17</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO17</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31810aXOa505a3f19f25843c4b31810900">
              <SHORT-NAME>ISatCNO18</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite18 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比18
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO18</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO18</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31886dXOa505a3f19f25843c4b31886c00">
              <SHORT-NAME>ISatCNO19</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite19 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比19
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO19</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO19</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31808eXOa505a3f19f25843c4b31808d00">
              <SHORT-NAME>ISatCNO2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite2 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比2
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3183b4XOa505a3f19f25843c4b3183b300">
              <SHORT-NAME>ISatCNO20</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite20 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比20
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO20</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO20</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3189e1XOa505a3f19f25843c4b3189e000">
              <SHORT-NAME>ISatCNO3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite3 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比3
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31827eXOa505a3f19f25843c4b31827d00">
              <SHORT-NAME>ISatCNO4</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite4 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比4
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO4</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31844fXOa505a3f19f25843c4b31844e00">
              <SHORT-NAME>ISatCNO5</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite5 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比5
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO5</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3184acXOa505a3f19f25843c4b3184ab00">
              <SHORT-NAME>ISatCNO6</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite6 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比6
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO6</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318319XOa505a3f19f25843c4b31831800">
              <SHORT-NAME>ISatCNO7</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite7 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比7
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO7</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO7</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3184eaXOa505a3f19f25843c4b3184e900">
              <SHORT-NAME>ISatCNO8</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite8 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比8
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO8</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO8</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO8</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318c6cXOa505a3f19f25843c4b318c6b00">
              <SHORT-NAME>ISatCNO9</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite9 Cno</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星信噪比9
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatCNO9</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatCNO9</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatCNO9</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318b74XOa505a3f19f25843c4b318b7300">
              <SHORT-NAME>ISatElv1</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite1 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角1
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv1</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv1</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv1</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317f39XOa505a3f19f25843c4b317f3800">
              <SHORT-NAME>ISatElv10</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite10 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角10
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv10</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv10</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv10</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31882fXOa505a3f19f25843c4b31882e00">
              <SHORT-NAME>ISatElv11</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite11 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角11
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv11</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv11</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv11</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318737XOa505a3f19f25843c4b31873600">
              <SHORT-NAME>ISatElv12</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite12 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角12
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv12</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv12</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv12</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318411XOa505a3f19f25843c4b31841000">
              <SHORT-NAME>ISatElv13</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite13 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角13
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv13</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv13</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv13</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3182faXOa505a3f19f25843c4b3182f900">
              <SHORT-NAME>ISatElv14</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite14 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角14
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv14</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv14</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv14</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318050XOa505a3f19f25843c4b31804f00">
              <SHORT-NAME>ISatElv15</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite15 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角15
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv15</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv15</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv15</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3187f1XOa505a3f19f25843c4b3187f000">
              <SHORT-NAME>ISatElv16</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite16 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角16
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv16</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv16</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv16</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b3186bbXOa505a3f19f25843c4b3186ba00">
              <SHORT-NAME>ISatElv17</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite17 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角17
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv17</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv17</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv17</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317fd4XOa505a3f19f25843c4b317fd300">
              <SHORT-NAME>ISatElv18</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite18 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角18
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv18</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv18</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv18</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318908XOa505a3f19f25843c4b31890700">
              <SHORT-NAME>ISatElv19</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite19 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角19
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv19</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv19</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv19</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b317e9eXOa505a3f19f25843c4b317e9d00">
              <SHORT-NAME>ISatElv2</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite2 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角2
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv2</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv2</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv2</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318620XOa505a3f19f25843c4b31861f00">
              <SHORT-NAME>ISatElv20</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite20 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角20
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv20</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv20</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv20</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318bb2XOa505a3f19f25843c4b318bb100">
              <SHORT-NAME>ISatElv3</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite3 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角3
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv3</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv3</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv3</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318148XOa505a3f19f25843c4b31814700">
              <SHORT-NAME>ISatElv4</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite4 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角4
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv4</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv4</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv4</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318566XOa505a3f19f25843c4b31856500">
              <SHORT-NAME>ISatElv5</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite5 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角5
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv5</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv5</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv5</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b318202XOa505a3f19f25843c4b31820100">
              <SHORT-NAME>ISatElv6</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite6 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角6
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv6</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv6</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
              </NETWORK-REPRESENTATION-PROPS>
              <SYSTEM-SIGNAL-REF DEST="SYSTEM-SIGNAL">/Communication/SystemSignals/SatElv6</SYSTEM-SIGNAL-REF>
            </I-SIGNAL>
            <I-SIGNAL UUID="Oa505a3f19f25843c4b31829dXOa505a3f19f25843c4b31829c00">
              <SHORT-NAME>ISatElv7</SHORT-NAME>
              <LONG-NAME>
                <L-4 L="EN">Satellite7 Elevation Angle</L-4>
              </LONG-NAME>
              <DESC>
                <L-2 L="EN">Period(ms):1000.0
Signal Group:
功能安全:
信息安全:
有无服务标签:
发送方描述:卫星仰角7
接收方描述:IPD
Max. acceptable latency(ms):null
Repetition Period(ms):NA
Num. Of Repetition:NA
Signal Type:UNM
备注:定位</L-2>
              </DESC>
              <DATA-TYPE-POLICY>OVERRIDE</DATA-TYPE-POLICY>
              <I-SIGNAL-PROPS>
                <HANDLE-OUT-OF-RANGE>IGNORE</HANDLE-OUT-OF-RANGE>
              </I-SIGNAL-PROPS>
              <INIT-VALUE>
                <NUMERICAL-VALUE-SPECIFICATION>
                  <SHORT-LABEL>SatElv7</SHORT-LABEL>
                  <VALUE>0x0</VALUE>
                </NUMERICAL-VALUE-SPECIFICATION>
              </INIT-VALUE>
              <LENGTH>7</LENGTH>
              <NETWORK-REPRESENTATION-PROPS>
                <SW-DATA-DEF-PROPS-VARIANTS>
                  <SW-DATA-DEF-PROPS-CONDITIONAL>
                    <BASE-TYPE-REF DEST="SW-BASE-TYPE">/DataTypes/BaseTypes/UINT8</BASE-TYPE-REF>
                    <COMPU-METHOD-REF DEST="COMPU-METHOD">/DataTypes/CompuMethods/SatElv7</COMPU-METHOD-REF>
                  </SW-DATA-DEF-PROPS-CONDITIONAL>
                </SW-DATA-DEF-PROPS-VARIANTS>
